C {./filltie.sym} 810 19500 0 0 {name=XTAP_TAPCELL_ROW_45_332}
N 718 19500 698 19500 {lab=VDD}
C {./lab_pin.sym} 698 19500 0 0 {name=l1034_0 lab=VDD}
N 902 19500 922 19500 {lab=VSS}
C {./lab_pin.sym} 922 19500 0 1 {name=l1034_1 lab=VSS}
C {./filltie.sym} 1215 19500 0 0 {name=XTAP_TAPCELL_ROW_45_333}
N 1123 19500 1103 19500 {lab=VDD}
C {./lab_pin.sym} 1103 19500 0 0 {name=l1035_0 lab=VDD}
N 1307 19500 1327 19500 {lab=VSS}
C {./lab_pin.sym} 1327 19500 0 1 {name=l1035_1 lab=VSS}
C {./filltie.sym} 1620 19500 0 0 {name=XTAP_TAPCELL_ROW_45_334}
N 1528 19500 1508 19500 {lab=VDD}
C {./lab_pin.sym} 1508 19500 0 0 {name=l1036_0 lab=VDD}
N 1712 19500 1732 19500 {lab=VSS}
C {./lab_pin.sym} 1732 19500 0 1 {name=l1036_1 lab=VSS}
C {./filltie.sym} 2025 19500 0 0 {name=XTAP_TAPCELL_ROW_45_335}
N 1933 19500 1913 19500 {lab=VDD}
C {./lab_pin.sym} 1913 19500 0 0 {name=l1037_0 lab=VDD}
N 2117 19500 2137 19500 {lab=VSS}
C {./lab_pin.sym} 2137 19500 0 1 {name=l1037_1 lab=VSS}
C {./filltie.sym} 2430 19500 0 0 {name=XTAP_TAPCELL_ROW_46_336}
N 2338 19500 2318 19500 {lab=VDD}
C {./lab_pin.sym} 2318 19500 0 0 {name=l1038_0 lab=VDD}
N 2522 19500 2542 19500 {lab=VSS}
C {./lab_pin.sym} 2542 19500 0 1 {name=l1038_1 lab=VSS}
C {./filltie.sym} 2835 19500 0 0 {name=XTAP_TAPCELL_ROW_46_337}
N 2743 19500 2723 19500 {lab=VDD}
C {./lab_pin.sym} 2723 19500 0 0 {name=l1039_0 lab=VDD}
N 2927 19500 2947 19500 {lab=VSS}
C {./lab_pin.sym} 2947 19500 0 1 {name=l1039_1 lab=VSS}
C {./filltie.sym} 3240 19500 0 0 {name=XTAP_TAPCELL_ROW_46_338}
N 3148 19500 3128 19500 {lab=VDD}
C {./lab_pin.sym} 3128 19500 0 0 {name=l1040_0 lab=VDD}
N 3332 19500 3352 19500 {lab=VSS}
C {./lab_pin.sym} 3352 19500 0 1 {name=l1040_1 lab=VSS}
C {./filltie.sym} 3645 19500 0 0 {name=XTAP_TAPCELL_ROW_46_339}
N 3553 19500 3533 19500 {lab=VDD}
C {./lab_pin.sym} 3533 19500 0 0 {name=l1041_0 lab=VDD}
N 3737 19500 3757 19500 {lab=VSS}
C {./lab_pin.sym} 3757 19500 0 1 {name=l1041_1 lab=VSS}
C {./filltie.sym} 4050 19500 0 0 {name=XTAP_TAPCELL_ROW_46_340}
N 3958 19500 3938 19500 {lab=VDD}
C {./lab_pin.sym} 3938 19500 0 0 {name=l1042_0 lab=VDD}
N 4142 19500 4162 19500 {lab=VSS}
C {./lab_pin.sym} 4162 19500 0 1 {name=l1042_1 lab=VSS}
C {./filltie.sym} 4455 19500 0 0 {name=XTAP_TAPCELL_ROW_47_341}
N 4363 19500 4343 19500 {lab=VDD}
C {./lab_pin.sym} 4343 19500 0 0 {name=l1043_0 lab=VDD}
N 4547 19500 4567 19500 {lab=VSS}
C {./lab_pin.sym} 4567 19500 0 1 {name=l1043_1 lab=VSS}
C {./filltie.sym} 0 19725 0 0 {name=XTAP_TAPCELL_ROW_47_342}
N -92 19725 -112 19725 {lab=VDD}
C {./lab_pin.sym} -112 19725 0 0 {name=l1044_0 lab=VDD}
N 92 19725 112 19725 {lab=VSS}
C {./lab_pin.sym} 112 19725 0 1 {name=l1044_1 lab=VSS}
C {./filltie.sym} 405 19725 0 0 {name=XTAP_TAPCELL_ROW_47_343}
N 313 19725 293 19725 {lab=VDD}
C {./lab_pin.sym} 293 19725 0 0 {name=l1045_0 lab=VDD}
N 497 19725 517 19725 {lab=VSS}
C {./lab_pin.sym} 517 19725 0 1 {name=l1045_1 lab=VSS}
C {./filltie.sym} 810 19725 0 0 {name=XTAP_TAPCELL_ROW_47_344}
N 718 19725 698 19725 {lab=VDD}
C {./lab_pin.sym} 698 19725 0 0 {name=l1046_0 lab=VDD}
N 902 19725 922 19725 {lab=VSS}
C {./lab_pin.sym} 922 19725 0 1 {name=l1046_1 lab=VSS}
C {./filltie.sym} 1215 19725 0 0 {name=XTAP_TAPCELL_ROW_47_345}
N 1123 19725 1103 19725 {lab=VDD}
C {./lab_pin.sym} 1103 19725 0 0 {name=l1047_0 lab=VDD}
N 1307 19725 1327 19725 {lab=VSS}
C {./lab_pin.sym} 1327 19725 0 1 {name=l1047_1 lab=VSS}
C {./filltie.sym} 1620 19725 0 0 {name=XTAP_TAPCELL_ROW_48_346}
N 1528 19725 1508 19725 {lab=VDD}
C {./lab_pin.sym} 1508 19725 0 0 {name=l1048_0 lab=VDD}
N 1712 19725 1732 19725 {lab=VSS}
C {./lab_pin.sym} 1732 19725 0 1 {name=l1048_1 lab=VSS}
C {./filltie.sym} 2025 19725 0 0 {name=XTAP_TAPCELL_ROW_48_347}
N 1933 19725 1913 19725 {lab=VDD}
C {./lab_pin.sym} 1913 19725 0 0 {name=l1049_0 lab=VDD}
N 2117 19725 2137 19725 {lab=VSS}
C {./lab_pin.sym} 2137 19725 0 1 {name=l1049_1 lab=VSS}
C {./filltie.sym} 2430 19725 0 0 {name=XTAP_TAPCELL_ROW_48_348}
N 2338 19725 2318 19725 {lab=VDD}
C {./lab_pin.sym} 2318 19725 0 0 {name=l1050_0 lab=VDD}
N 2522 19725 2542 19725 {lab=VSS}
C {./lab_pin.sym} 2542 19725 0 1 {name=l1050_1 lab=VSS}
C {./filltie.sym} 2835 19725 0 0 {name=XTAP_TAPCELL_ROW_48_349}
N 2743 19725 2723 19725 {lab=VDD}
C {./lab_pin.sym} 2723 19725 0 0 {name=l1051_0 lab=VDD}
N 2927 19725 2947 19725 {lab=VSS}
C {./lab_pin.sym} 2947 19725 0 1 {name=l1051_1 lab=VSS}
C {./filltie.sym} 3240 19725 0 0 {name=XTAP_TAPCELL_ROW_48_350}
N 3148 19725 3128 19725 {lab=VDD}
C {./lab_pin.sym} 3128 19725 0 0 {name=l1052_0 lab=VDD}
N 3332 19725 3352 19725 {lab=VSS}
C {./lab_pin.sym} 3352 19725 0 1 {name=l1052_1 lab=VSS}
C {./filltie.sym} 3645 19725 0 0 {name=XTAP_TAPCELL_ROW_49_351}
N 3553 19725 3533 19725 {lab=VDD}
C {./lab_pin.sym} 3533 19725 0 0 {name=l1053_0 lab=VDD}
N 3737 19725 3757 19725 {lab=VSS}
C {./lab_pin.sym} 3757 19725 0 1 {name=l1053_1 lab=VSS}
C {./filltie.sym} 4050 19725 0 0 {name=XTAP_TAPCELL_ROW_49_352}
N 3958 19725 3938 19725 {lab=VDD}
C {./lab_pin.sym} 3938 19725 0 0 {name=l1054_0 lab=VDD}
N 4142 19725 4162 19725 {lab=VSS}
C {./lab_pin.sym} 4162 19725 0 1 {name=l1054_1 lab=VSS}
C {./filltie.sym} 4455 19725 0 0 {name=XTAP_TAPCELL_ROW_49_353}
N 4363 19725 4343 19725 {lab=VDD}
C {./lab_pin.sym} 4343 19725 0 0 {name=l1055_0 lab=VDD}
N 4547 19725 4567 19725 {lab=VSS}
C {./lab_pin.sym} 4567 19725 0 1 {name=l1055_1 lab=VSS}
C {./filltie.sym} 0 19950 0 0 {name=XTAP_TAPCELL_ROW_49_354}
N -92 19950 -112 19950 {lab=VDD}
C {./lab_pin.sym} -112 19950 0 0 {name=l1056_0 lab=VDD}
N 92 19950 112 19950 {lab=VSS}
C {./lab_pin.sym} 112 19950 0 1 {name=l1056_1 lab=VSS}
C {./filltie.sym} 405 19950 0 0 {name=XTAP_TAPCELL_ROW_49_355}
N 313 19950 293 19950 {lab=VDD}
C {./lab_pin.sym} 293 19950 0 0 {name=l1057_0 lab=VDD}
N 497 19950 517 19950 {lab=VSS}
C {./lab_pin.sym} 517 19950 0 1 {name=l1057_1 lab=VSS}
C {./filltie.sym} 810 19950 0 0 {name=XTAP_TAPCELL_ROW_49_356}
N 718 19950 698 19950 {lab=VDD}
C {./lab_pin.sym} 698 19950 0 0 {name=l1058_0 lab=VDD}
N 902 19950 922 19950 {lab=VSS}
C {./lab_pin.sym} 922 19950 0 1 {name=l1058_1 lab=VSS}
C {./filltie.sym} 1215 19950 0 0 {name=XTAP_TAPCELL_ROW_49_357}
N 1123 19950 1103 19950 {lab=VDD}
C {./lab_pin.sym} 1103 19950 0 0 {name=l1059_0 lab=VDD}
N 1307 19950 1327 19950 {lab=VSS}
C {./lab_pin.sym} 1327 19950 0 1 {name=l1059_1 lab=VSS}
C {./filltie.sym} 1620 19950 0 0 {name=XTAP_TAPCELL_ROW_49_358}
N 1528 19950 1508 19950 {lab=VDD}
C {./lab_pin.sym} 1508 19950 0 0 {name=l1060_0 lab=VDD}
N 1712 19950 1732 19950 {lab=VSS}
C {./lab_pin.sym} 1732 19950 0 1 {name=l1060_1 lab=VSS}
C {./filltie.sym} 2025 19950 0 0 {name=XTAP_TAPCELL_ROW_49_359}
N 1933 19950 1913 19950 {lab=VDD}
C {./lab_pin.sym} 1913 19950 0 0 {name=l1061_0 lab=VDD}
N 2117 19950 2137 19950 {lab=VSS}
C {./lab_pin.sym} 2137 19950 0 1 {name=l1061_1 lab=VSS}
C {./filltie.sym} 2430 19950 0 0 {name=XTAP_TAPCELL_ROW_49_360}
N 2338 19950 2318 19950 {lab=VDD}
C {./lab_pin.sym} 2318 19950 0 0 {name=l1062_0 lab=VDD}
N 2522 19950 2542 19950 {lab=VSS}
C {./lab_pin.sym} 2542 19950 0 1 {name=l1062_1 lab=VSS}
C {./filltie.sym} 2835 19950 0 0 {name=XTAP_TAPCELL_ROW_49_361}
N 2743 19950 2723 19950 {lab=VDD}
C {./lab_pin.sym} 2723 19950 0 0 {name=l1063_0 lab=VDD}
N 2927 19950 2947 19950 {lab=VSS}
C {./lab_pin.sym} 2947 19950 0 1 {name=l1063_1 lab=VSS}
C {./filltie.sym} 3240 19950 0 0 {name=XTAP_TAPCELL_ROW_4_126}
N 3148 19950 3128 19950 {lab=VDD}
C {./lab_pin.sym} 3128 19950 0 0 {name=l1064_0 lab=VDD}
N 3332 19950 3352 19950 {lab=VSS}
C {./lab_pin.sym} 3352 19950 0 1 {name=l1064_1 lab=VSS}
C {./filltie.sym} 3645 19950 0 0 {name=XTAP_TAPCELL_ROW_4_127}
N 3553 19950 3533 19950 {lab=VDD}
C {./lab_pin.sym} 3533 19950 0 0 {name=l1065_0 lab=VDD}
N 3737 19950 3757 19950 {lab=VSS}
C {./lab_pin.sym} 3757 19950 0 1 {name=l1065_1 lab=VSS}
C {./filltie.sym} 4050 19950 0 0 {name=XTAP_TAPCELL_ROW_4_128}
N 3958 19950 3938 19950 {lab=VDD}
C {./lab_pin.sym} 3938 19950 0 0 {name=l1066_0 lab=VDD}
N 4142 19950 4162 19950 {lab=VSS}
C {./lab_pin.sym} 4162 19950 0 1 {name=l1066_1 lab=VSS}
C {./filltie.sym} 4455 19950 0 0 {name=XTAP_TAPCELL_ROW_4_129}
N 4363 19950 4343 19950 {lab=VDD}
C {./lab_pin.sym} 4343 19950 0 0 {name=l1067_0 lab=VDD}
N 4547 19950 4567 19950 {lab=VSS}
C {./lab_pin.sym} 4567 19950 0 1 {name=l1067_1 lab=VSS}
C {./filltie.sym} 0 20175 0 0 {name=XTAP_TAPCELL_ROW_4_130}
N -92 20175 -112 20175 {lab=VDD}
C {./lab_pin.sym} -112 20175 0 0 {name=l1068_0 lab=VDD}
N 92 20175 112 20175 {lab=VSS}
C {./lab_pin.sym} 112 20175 0 1 {name=l1068_1 lab=VSS}
C {./filltie.sym} 405 20175 0 0 {name=XTAP_TAPCELL_ROW_5_131}
N 313 20175 293 20175 {lab=VDD}
C {./lab_pin.sym} 293 20175 0 0 {name=l1069_0 lab=VDD}
N 497 20175 517 20175 {lab=VSS}
C {./lab_pin.sym} 517 20175 0 1 {name=l1069_1 lab=VSS}
C {./filltie.sym} 810 20175 0 0 {name=XTAP_TAPCELL_ROW_5_132}
N 718 20175 698 20175 {lab=VDD}
C {./lab_pin.sym} 698 20175 0 0 {name=l1070_0 lab=VDD}
N 902 20175 922 20175 {lab=VSS}
C {./lab_pin.sym} 922 20175 0 1 {name=l1070_1 lab=VSS}
C {./filltie.sym} 1215 20175 0 0 {name=XTAP_TAPCELL_ROW_5_133}
N 1123 20175 1103 20175 {lab=VDD}
C {./lab_pin.sym} 1103 20175 0 0 {name=l1071_0 lab=VDD}
N 1307 20175 1327 20175 {lab=VSS}
C {./lab_pin.sym} 1327 20175 0 1 {name=l1071_1 lab=VSS}
C {./filltie.sym} 1620 20175 0 0 {name=XTAP_TAPCELL_ROW_5_134}
N 1528 20175 1508 20175 {lab=VDD}
C {./lab_pin.sym} 1508 20175 0 0 {name=l1072_0 lab=VDD}
N 1712 20175 1732 20175 {lab=VSS}
C {./lab_pin.sym} 1732 20175 0 1 {name=l1072_1 lab=VSS}
C {./filltie.sym} 2025 20175 0 0 {name=XTAP_TAPCELL_ROW_5_135}
N 1933 20175 1913 20175 {lab=VDD}
C {./lab_pin.sym} 1913 20175 0 0 {name=l1073_0 lab=VDD}
N 2117 20175 2137 20175 {lab=VSS}
C {./lab_pin.sym} 2137 20175 0 1 {name=l1073_1 lab=VSS}
C {./filltie.sym} 2430 20175 0 0 {name=XTAP_TAPCELL_ROW_6_136}
N 2338 20175 2318 20175 {lab=VDD}
C {./lab_pin.sym} 2318 20175 0 0 {name=l1074_0 lab=VDD}
N 2522 20175 2542 20175 {lab=VSS}
C {./lab_pin.sym} 2542 20175 0 1 {name=l1074_1 lab=VSS}
C {./filltie.sym} 2835 20175 0 0 {name=XTAP_TAPCELL_ROW_6_137}
N 2743 20175 2723 20175 {lab=VDD}
C {./lab_pin.sym} 2723 20175 0 0 {name=l1075_0 lab=VDD}
N 2927 20175 2947 20175 {lab=VSS}
C {./lab_pin.sym} 2947 20175 0 1 {name=l1075_1 lab=VSS}
C {./filltie.sym} 3240 20175 0 0 {name=XTAP_TAPCELL_ROW_6_138}
N 3148 20175 3128 20175 {lab=VDD}
C {./lab_pin.sym} 3128 20175 0 0 {name=l1076_0 lab=VDD}
N 3332 20175 3352 20175 {lab=VSS}
C {./lab_pin.sym} 3352 20175 0 1 {name=l1076_1 lab=VSS}
C {./filltie.sym} 3645 20175 0 0 {name=XTAP_TAPCELL_ROW_6_139}
N 3553 20175 3533 20175 {lab=VDD}
C {./lab_pin.sym} 3533 20175 0 0 {name=l1077_0 lab=VDD}
N 3737 20175 3757 20175 {lab=VSS}
C {./lab_pin.sym} 3757 20175 0 1 {name=l1077_1 lab=VSS}
C {./filltie.sym} 4050 20175 0 0 {name=XTAP_TAPCELL_ROW_6_140}
N 3958 20175 3938 20175 {lab=VDD}
C {./lab_pin.sym} 3938 20175 0 0 {name=l1078_0 lab=VDD}
N 4142 20175 4162 20175 {lab=VSS}
C {./lab_pin.sym} 4162 20175 0 1 {name=l1078_1 lab=VSS}
C {./filltie.sym} 4455 20175 0 0 {name=XTAP_TAPCELL_ROW_7_141}
N 4363 20175 4343 20175 {lab=VDD}
C {./lab_pin.sym} 4343 20175 0 0 {name=l1079_0 lab=VDD}
N 4547 20175 4567 20175 {lab=VSS}
C {./lab_pin.sym} 4567 20175 0 1 {name=l1079_1 lab=VSS}
C {./filltie.sym} 0 20400 0 0 {name=XTAP_TAPCELL_ROW_7_142}
N -92 20400 -112 20400 {lab=VDD}
C {./lab_pin.sym} -112 20400 0 0 {name=l1080_0 lab=VDD}
N 92 20400 112 20400 {lab=VSS}
C {./lab_pin.sym} 112 20400 0 1 {name=l1080_1 lab=VSS}
C {./filltie.sym} 405 20400 0 0 {name=XTAP_TAPCELL_ROW_7_143}
N 313 20400 293 20400 {lab=VDD}
C {./lab_pin.sym} 293 20400 0 0 {name=l1081_0 lab=VDD}
N 497 20400 517 20400 {lab=VSS}
C {./lab_pin.sym} 517 20400 0 1 {name=l1081_1 lab=VSS}
C {./filltie.sym} 810 20400 0 0 {name=XTAP_TAPCELL_ROW_7_144}
N 718 20400 698 20400 {lab=VDD}
C {./lab_pin.sym} 698 20400 0 0 {name=l1082_0 lab=VDD}
N 902 20400 922 20400 {lab=VSS}
C {./lab_pin.sym} 922 20400 0 1 {name=l1082_1 lab=VSS}
C {./filltie.sym} 1215 20400 0 0 {name=XTAP_TAPCELL_ROW_7_145}
N 1123 20400 1103 20400 {lab=VDD}
C {./lab_pin.sym} 1103 20400 0 0 {name=l1083_0 lab=VDD}
N 1307 20400 1327 20400 {lab=VSS}
C {./lab_pin.sym} 1327 20400 0 1 {name=l1083_1 lab=VSS}
C {./filltie.sym} 1620 20400 0 0 {name=XTAP_TAPCELL_ROW_8_146}
N 1528 20400 1508 20400 {lab=VDD}
C {./lab_pin.sym} 1508 20400 0 0 {name=l1084_0 lab=VDD}
N 1712 20400 1732 20400 {lab=VSS}
C {./lab_pin.sym} 1732 20400 0 1 {name=l1084_1 lab=VSS}
C {./filltie.sym} 2025 20400 0 0 {name=XTAP_TAPCELL_ROW_8_147}
N 1933 20400 1913 20400 {lab=VDD}
C {./lab_pin.sym} 1913 20400 0 0 {name=l1085_0 lab=VDD}
N 2117 20400 2137 20400 {lab=VSS}
C {./lab_pin.sym} 2137 20400 0 1 {name=l1085_1 lab=VSS}
C {./filltie.sym} 2430 20400 0 0 {name=XTAP_TAPCELL_ROW_8_148}
N 2338 20400 2318 20400 {lab=VDD}
C {./lab_pin.sym} 2318 20400 0 0 {name=l1086_0 lab=VDD}
N 2522 20400 2542 20400 {lab=VSS}
C {./lab_pin.sym} 2542 20400 0 1 {name=l1086_1 lab=VSS}
C {./filltie.sym} 2835 20400 0 0 {name=XTAP_TAPCELL_ROW_8_149}
N 2743 20400 2723 20400 {lab=VDD}
C {./lab_pin.sym} 2723 20400 0 0 {name=l1087_0 lab=VDD}
N 2927 20400 2947 20400 {lab=VSS}
C {./lab_pin.sym} 2947 20400 0 1 {name=l1087_1 lab=VSS}
C {./filltie.sym} 3240 20400 0 0 {name=XTAP_TAPCELL_ROW_8_150}
N 3148 20400 3128 20400 {lab=VDD}
C {./lab_pin.sym} 3128 20400 0 0 {name=l1088_0 lab=VDD}
N 3332 20400 3352 20400 {lab=VSS}
C {./lab_pin.sym} 3352 20400 0 1 {name=l1088_1 lab=VSS}
C {./filltie.sym} 3645 20400 0 0 {name=XTAP_TAPCELL_ROW_9_151}
N 3553 20400 3533 20400 {lab=VDD}
C {./lab_pin.sym} 3533 20400 0 0 {name=l1089_0 lab=VDD}
N 3737 20400 3757 20400 {lab=VSS}
C {./lab_pin.sym} 3757 20400 0 1 {name=l1089_1 lab=VSS}
C {./filltie.sym} 4050 20400 0 0 {name=XTAP_TAPCELL_ROW_9_152}
N 3958 20400 3938 20400 {lab=VDD}
C {./lab_pin.sym} 3938 20400 0 0 {name=l1090_0 lab=VDD}
N 4142 20400 4162 20400 {lab=VSS}
C {./lab_pin.sym} 4162 20400 0 1 {name=l1090_1 lab=VSS}
C {./filltie.sym} 4455 20400 0 0 {name=XTAP_TAPCELL_ROW_9_153}
N 4363 20400 4343 20400 {lab=VDD}
C {./lab_pin.sym} 4343 20400 0 0 {name=l1091_0 lab=VDD}
N 4547 20400 4567 20400 {lab=VSS}
C {./lab_pin.sym} 4567 20400 0 1 {name=l1091_1 lab=VSS}
C {./filltie.sym} 0 20625 0 0 {name=XTAP_TAPCELL_ROW_9_154}
N -92 20625 -112 20625 {lab=VDD}
C {./lab_pin.sym} -112 20625 0 0 {name=l1092_0 lab=VDD}
N 92 20625 112 20625 {lab=VSS}
C {./lab_pin.sym} 112 20625 0 1 {name=l1092_1 lab=VSS}
C {./filltie.sym} 405 20625 0 0 {name=XTAP_TAPCELL_ROW_9_155}
N 313 20625 293 20625 {lab=VDD}
C {./lab_pin.sym} 293 20625 0 0 {name=l1093_0 lab=VDD}
N 497 20625 517 20625 {lab=VSS}
C {./lab_pin.sym} 517 20625 0 1 {name=l1093_1 lab=VSS}
C {./clkinv_1.sym} 810 20625 0 0 {name=Xn_1035}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__clkinv_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -40 72 -40 {}
L 4 72 -40 72 40 {}
L 4 72 40 -72 40 {}
L 4 -72 40 -72 -40 {}
T {@name} -72 -60 0 0 0.33 0.33 {}
T {clkinv_1} -68 29 0 0 0.2 0.2 {}
L 4 -92 -20 -72 -20 {}
T {I} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {ZN} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {VDD} -66 15 0 0 0.16 0.16 {}
L 4 92 -20 72 -20 {}
T {VNW} 50.2 -25 0 0 0.16 0.16 {}
L 4 92 0 72 0 {}
T {VPW} 50.2 -5 0 0 0.16 0.16 {}
L 4 92 20 72 20 {}
T {VSS} 50.2 15 0 0 0.16 0.16 {}
B 5 -94 -22 -90 -18 {name=I dir=inout sim_pinnumber=1}
B 5 -94 -2 -90 2 {name=ZN dir=inout sim_pinnumber=2}
B 5 -94 18 -90 22 {name=VDD dir=inout sim_pinnumber=3}
B 5 90 -22 94 -18 {name=VNW dir=inout sim_pinnumber=4}
B 5 90 -2 94 2 {name=VPW dir=inout sim_pinnumber=5}
B 5 90 18 94 22 {name=VSS dir=inout sim_pinnumber=6}
]
N 718 20605 698 20605 {lab=out_cas_int_b1}
C {./lab_pin.sym} 698 20605 0 0 {name=l1094_0 lab=out_cas_int_b1}
N 718 20625 698 20625 {lab=n_0478}
C {./lab_pin.sym} 698 20625 0 0 {name=l1094_1 lab=n_0478}
N 718 20645 698 20645 {lab=VDD}
C {./lab_pin.sym} 698 20645 0 0 {name=l1094_2 lab=VDD}
N 902 20605 922 20605 {lab=VDD}
C {./lab_pin.sym} 922 20605 0 1 {name=l1094_3 lab=VDD}
N 902 20625 922 20625 {lab=VSS}
C {./lab_pin.sym} 922 20625 0 1 {name=l1094_4 lab=VSS}
N 902 20645 922 20645 {lab=VSS}
C {./lab_pin.sym} 922 20645 0 1 {name=l1094_5 lab=VSS}
C {./clkinv_1.sym} 1215 20625 0 0 {name=Xn_1036}
N 1123 20605 1103 20605 {lab=out_cas_int_b0}
C {./lab_pin.sym} 1103 20605 0 0 {name=l1095_0 lab=out_cas_int_b0}
N 1123 20625 1103 20625 {lab=n_0479}
C {./lab_pin.sym} 1103 20625 0 0 {name=l1095_1 lab=n_0479}
N 1123 20645 1103 20645 {lab=VDD}
C {./lab_pin.sym} 1103 20645 0 0 {name=l1095_2 lab=VDD}
N 1307 20605 1327 20605 {lab=VDD}
C {./lab_pin.sym} 1327 20605 0 1 {name=l1095_3 lab=VDD}
N 1307 20625 1327 20625 {lab=VSS}
C {./lab_pin.sym} 1327 20625 0 1 {name=l1095_4 lab=VSS}
N 1307 20645 1327 20645 {lab=VSS}
C {./lab_pin.sym} 1327 20645 0 1 {name=l1095_5 lab=VSS}
C {./clkinv_1.sym} 1620 20625 0 0 {name=Xn_1037}
N 1528 20605 1508 20605 {lab=out_cas_int_b2}
C {./lab_pin.sym} 1508 20605 0 0 {name=l1096_0 lab=out_cas_int_b2}
N 1528 20625 1508 20625 {lab=n_0480}
C {./lab_pin.sym} 1508 20625 0 0 {name=l1096_1 lab=n_0480}
N 1528 20645 1508 20645 {lab=VDD}
C {./lab_pin.sym} 1508 20645 0 0 {name=l1096_2 lab=VDD}
N 1712 20605 1732 20605 {lab=VDD}
C {./lab_pin.sym} 1732 20605 0 1 {name=l1096_3 lab=VDD}
N 1712 20625 1732 20625 {lab=VSS}
C {./lab_pin.sym} 1732 20625 0 1 {name=l1096_4 lab=VSS}
N 1712 20645 1732 20645 {lab=VSS}
C {./lab_pin.sym} 1732 20645 0 1 {name=l1096_5 lab=VSS}
C {./clkinv_1.sym} 2025 20625 0 0 {name=Xn_1038}
N 1933 20605 1913 20605 {lab=out_cas_int_b3}
C {./lab_pin.sym} 1913 20605 0 0 {name=l1097_0 lab=out_cas_int_b3}
N 1933 20625 1913 20625 {lab=n_0481}
C {./lab_pin.sym} 1913 20625 0 0 {name=l1097_1 lab=n_0481}
N 1933 20645 1913 20645 {lab=VDD}
C {./lab_pin.sym} 1913 20645 0 0 {name=l1097_2 lab=VDD}
N 2117 20605 2137 20605 {lab=VDD}
C {./lab_pin.sym} 2137 20605 0 1 {name=l1097_3 lab=VDD}
N 2117 20625 2137 20625 {lab=VSS}
C {./lab_pin.sym} 2137 20625 0 1 {name=l1097_4 lab=VSS}
N 2117 20645 2137 20645 {lab=VSS}
C {./lab_pin.sym} 2137 20645 0 1 {name=l1097_5 lab=VSS}
C {./clkinv_1.sym} 2430 20625 0 0 {name=Xn_1039}
N 2338 20605 2318 20605 {lab=out_cas_int_b4}
C {./lab_pin.sym} 2318 20605 0 0 {name=l1098_0 lab=out_cas_int_b4}
N 2338 20625 2318 20625 {lab=n_0482}
C {./lab_pin.sym} 2318 20625 0 0 {name=l1098_1 lab=n_0482}
N 2338 20645 2318 20645 {lab=VDD}
C {./lab_pin.sym} 2318 20645 0 0 {name=l1098_2 lab=VDD}
N 2522 20605 2542 20605 {lab=VDD}
C {./lab_pin.sym} 2542 20605 0 1 {name=l1098_3 lab=VDD}
N 2522 20625 2542 20625 {lab=VSS}
C {./lab_pin.sym} 2542 20625 0 1 {name=l1098_4 lab=VSS}
N 2522 20645 2542 20645 {lab=VSS}
C {./lab_pin.sym} 2542 20645 0 1 {name=l1098_5 lab=VSS}
C {./clkinv_1.sym} 2835 20625 0 0 {name=Xn_1040}
N 2743 20605 2723 20605 {lab=out_cas_int_b5}
C {./lab_pin.sym} 2723 20605 0 0 {name=l1099_0 lab=out_cas_int_b5}
N 2743 20625 2723 20625 {lab=n_0483}
C {./lab_pin.sym} 2723 20625 0 0 {name=l1099_1 lab=n_0483}
N 2743 20645 2723 20645 {lab=VDD}
C {./lab_pin.sym} 2723 20645 0 0 {name=l1099_2 lab=VDD}
N 2927 20605 2947 20605 {lab=VDD}
C {./lab_pin.sym} 2947 20605 0 1 {name=l1099_3 lab=VDD}
N 2927 20625 2947 20625 {lab=VSS}
C {./lab_pin.sym} 2947 20625 0 1 {name=l1099_4 lab=VSS}
N 2927 20645 2947 20645 {lab=VSS}
C {./lab_pin.sym} 2947 20645 0 1 {name=l1099_5 lab=VSS}
C {./clkinv_1.sym} 3240 20625 0 0 {name=Xn_1041}
N 3148 20605 3128 20605 {lab=out_cas_int_b6}
C {./lab_pin.sym} 3128 20605 0 0 {name=l1100_0 lab=out_cas_int_b6}
N 3148 20625 3128 20625 {lab=n_0484}
C {./lab_pin.sym} 3128 20625 0 0 {name=l1100_1 lab=n_0484}
N 3148 20645 3128 20645 {lab=VDD}
C {./lab_pin.sym} 3128 20645 0 0 {name=l1100_2 lab=VDD}
N 3332 20605 3352 20605 {lab=VDD}
C {./lab_pin.sym} 3352 20605 0 1 {name=l1100_3 lab=VDD}
N 3332 20625 3352 20625 {lab=VSS}
C {./lab_pin.sym} 3352 20625 0 1 {name=l1100_4 lab=VSS}
N 3332 20645 3352 20645 {lab=VSS}
C {./lab_pin.sym} 3352 20645 0 1 {name=l1100_5 lab=VSS}
C {./clkinv_1.sym} 3645 20625 0 0 {name=Xn_1042}
N 3553 20605 3533 20605 {lab=out_cas_int_b7}
C {./lab_pin.sym} 3533 20605 0 0 {name=l1101_0 lab=out_cas_int_b7}
N 3553 20625 3533 20625 {lab=n_0485}
C {./lab_pin.sym} 3533 20625 0 0 {name=l1101_1 lab=n_0485}
N 3553 20645 3533 20645 {lab=VDD}
C {./lab_pin.sym} 3533 20645 0 0 {name=l1101_2 lab=VDD}
N 3737 20605 3757 20605 {lab=VDD}
C {./lab_pin.sym} 3757 20605 0 1 {name=l1101_3 lab=VDD}
N 3737 20625 3757 20625 {lab=VSS}
C {./lab_pin.sym} 3757 20625 0 1 {name=l1101_4 lab=VSS}
N 3737 20645 3757 20645 {lab=VSS}
C {./lab_pin.sym} 3757 20645 0 1 {name=l1101_5 lab=VSS}
C {./clkinv_1.sym} 4050 20625 0 0 {name=Xn_1043}
N 3958 20605 3938 20605 {lab=out_cas_int_b8}
C {./lab_pin.sym} 3938 20605 0 0 {name=l1102_0 lab=out_cas_int_b8}
N 3958 20625 3938 20625 {lab=n_0486}
C {./lab_pin.sym} 3938 20625 0 0 {name=l1102_1 lab=n_0486}
N 3958 20645 3938 20645 {lab=VDD}
C {./lab_pin.sym} 3938 20645 0 0 {name=l1102_2 lab=VDD}
N 4142 20605 4162 20605 {lab=VDD}
C {./lab_pin.sym} 4162 20605 0 1 {name=l1102_3 lab=VDD}
N 4142 20625 4162 20625 {lab=VSS}
C {./lab_pin.sym} 4162 20625 0 1 {name=l1102_4 lab=VSS}
N 4142 20645 4162 20645 {lab=VSS}
C {./lab_pin.sym} 4162 20645 0 1 {name=l1102_5 lab=VSS}
C {./clkinv_1.sym} 4455 20625 0 0 {name=Xn_1044}
N 4363 20605 4343 20605 {lab=out_cas_int_b9}
C {./lab_pin.sym} 4343 20605 0 0 {name=l1103_0 lab=out_cas_int_b9}
N 4363 20625 4343 20625 {lab=n_0487}
C {./lab_pin.sym} 4343 20625 0 0 {name=l1103_1 lab=n_0487}
N 4363 20645 4343 20645 {lab=VDD}
C {./lab_pin.sym} 4343 20645 0 0 {name=l1103_2 lab=VDD}
N 4547 20605 4567 20605 {lab=VDD}
C {./lab_pin.sym} 4567 20605 0 1 {name=l1103_3 lab=VDD}
N 4547 20625 4567 20625 {lab=VSS}
C {./lab_pin.sym} 4567 20625 0 1 {name=l1103_4 lab=VSS}
N 4547 20645 4567 20645 {lab=VSS}
C {./lab_pin.sym} 4567 20645 0 1 {name=l1103_5 lab=VSS}
C {./clkinv_1.sym} 0 20850 0 0 {name=Xn_1045}
N -92 20830 -112 20830 {lab=out_cas_int_b10}
C {./lab_pin.sym} -112 20830 0 0 {name=l1104_0 lab=out_cas_int_b10}
N -92 20850 -112 20850 {lab=n_0488}
C {./lab_pin.sym} -112 20850 0 0 {name=l1104_1 lab=n_0488}
N -92 20870 -112 20870 {lab=VDD}
C {./lab_pin.sym} -112 20870 0 0 {name=l1104_2 lab=VDD}
N 92 20830 112 20830 {lab=VDD}
C {./lab_pin.sym} 112 20830 0 1 {name=l1104_3 lab=VDD}
N 92 20850 112 20850 {lab=VSS}
C {./lab_pin.sym} 112 20850 0 1 {name=l1104_4 lab=VSS}
N 92 20870 112 20870 {lab=VSS}
C {./lab_pin.sym} 112 20870 0 1 {name=l1104_5 lab=VSS}
C {./clkinv_1.sym} 405 20850 0 0 {name=Xn_1046}
N 313 20830 293 20830 {lab=out_cas_int_b11}
C {./lab_pin.sym} 293 20830 0 0 {name=l1105_0 lab=out_cas_int_b11}
N 313 20850 293 20850 {lab=n_0489}
C {./lab_pin.sym} 293 20850 0 0 {name=l1105_1 lab=n_0489}
N 313 20870 293 20870 {lab=VDD}
C {./lab_pin.sym} 293 20870 0 0 {name=l1105_2 lab=VDD}
N 497 20830 517 20830 {lab=VDD}
C {./lab_pin.sym} 517 20830 0 1 {name=l1105_3 lab=VDD}
N 497 20850 517 20850 {lab=VSS}
C {./lab_pin.sym} 517 20850 0 1 {name=l1105_4 lab=VSS}
N 497 20870 517 20870 {lab=VSS}
C {./lab_pin.sym} 517 20870 0 1 {name=l1105_5 lab=VSS}
C {./clkinv_1.sym} 810 20850 0 0 {name=Xn_1047}
N 718 20830 698 20830 {lab=out_cas_int_b12}
C {./lab_pin.sym} 698 20830 0 0 {name=l1106_0 lab=out_cas_int_b12}
N 718 20850 698 20850 {lab=n_0490}
C {./lab_pin.sym} 698 20850 0 0 {name=l1106_1 lab=n_0490}
N 718 20870 698 20870 {lab=VDD}
C {./lab_pin.sym} 698 20870 0 0 {name=l1106_2 lab=VDD}
N 902 20830 922 20830 {lab=VDD}
C {./lab_pin.sym} 922 20830 0 1 {name=l1106_3 lab=VDD}
N 902 20850 922 20850 {lab=VSS}
C {./lab_pin.sym} 922 20850 0 1 {name=l1106_4 lab=VSS}
N 902 20870 922 20870 {lab=VSS}
C {./lab_pin.sym} 922 20870 0 1 {name=l1106_5 lab=VSS}
C {./clkinv_1.sym} 1215 20850 0 0 {name=Xn_1048}
N 1123 20830 1103 20830 {lab=out_cas_int_b13}
C {./lab_pin.sym} 1103 20830 0 0 {name=l1107_0 lab=out_cas_int_b13}
N 1123 20850 1103 20850 {lab=n_0491}
C {./lab_pin.sym} 1103 20850 0 0 {name=l1107_1 lab=n_0491}
N 1123 20870 1103 20870 {lab=VDD}
C {./lab_pin.sym} 1103 20870 0 0 {name=l1107_2 lab=VDD}
N 1307 20830 1327 20830 {lab=VDD}
C {./lab_pin.sym} 1327 20830 0 1 {name=l1107_3 lab=VDD}
N 1307 20850 1327 20850 {lab=VSS}
C {./lab_pin.sym} 1327 20850 0 1 {name=l1107_4 lab=VSS}
N 1307 20870 1327 20870 {lab=VSS}
C {./lab_pin.sym} 1327 20870 0 1 {name=l1107_5 lab=VSS}
C {./clkinv_1.sym} 1620 20850 0 0 {name=Xn_1049}
N 1528 20830 1508 20830 {lab=out_cas_int_b14}
C {./lab_pin.sym} 1508 20830 0 0 {name=l1108_0 lab=out_cas_int_b14}
N 1528 20850 1508 20850 {lab=n_0492}
C {./lab_pin.sym} 1508 20850 0 0 {name=l1108_1 lab=n_0492}
N 1528 20870 1508 20870 {lab=VDD}
C {./lab_pin.sym} 1508 20870 0 0 {name=l1108_2 lab=VDD}
N 1712 20830 1732 20830 {lab=VDD}
C {./lab_pin.sym} 1732 20830 0 1 {name=l1108_3 lab=VDD}
N 1712 20850 1732 20850 {lab=VSS}
C {./lab_pin.sym} 1732 20850 0 1 {name=l1108_4 lab=VSS}
N 1712 20870 1732 20870 {lab=VSS}
C {./lab_pin.sym} 1732 20870 0 1 {name=l1108_5 lab=VSS}
C {./clkinv_1.sym} 2025 20850 0 0 {name=Xn_1050}
N 1933 20830 1913 20830 {lab=out_cas_int_b15}
C {./lab_pin.sym} 1913 20830 0 0 {name=l1109_0 lab=out_cas_int_b15}
N 1933 20850 1913 20850 {lab=n_0493}
C {./lab_pin.sym} 1913 20850 0 0 {name=l1109_1 lab=n_0493}
N 1933 20870 1913 20870 {lab=VDD}
C {./lab_pin.sym} 1913 20870 0 0 {name=l1109_2 lab=VDD}
N 2117 20830 2137 20830 {lab=VDD}
C {./lab_pin.sym} 2137 20830 0 1 {name=l1109_3 lab=VDD}
N 2117 20850 2137 20850 {lab=VSS}
C {./lab_pin.sym} 2137 20850 0 1 {name=l1109_4 lab=VSS}
N 2117 20870 2137 20870 {lab=VSS}
C {./lab_pin.sym} 2137 20870 0 1 {name=l1109_5 lab=VSS}
C {./clkinv_1.sym} 2430 20850 0 0 {name=Xn_1051}
N 2338 20830 2318 20830 {lab=out_cas_int_b16}
C {./lab_pin.sym} 2318 20830 0 0 {name=l1110_0 lab=out_cas_int_b16}
N 2338 20850 2318 20850 {lab=n_0494}
C {./lab_pin.sym} 2318 20850 0 0 {name=l1110_1 lab=n_0494}
N 2338 20870 2318 20870 {lab=VDD}
C {./lab_pin.sym} 2318 20870 0 0 {name=l1110_2 lab=VDD}
N 2522 20830 2542 20830 {lab=VDD}
C {./lab_pin.sym} 2542 20830 0 1 {name=l1110_3 lab=VDD}
N 2522 20850 2542 20850 {lab=VSS}
C {./lab_pin.sym} 2542 20850 0 1 {name=l1110_4 lab=VSS}
N 2522 20870 2542 20870 {lab=VSS}
C {./lab_pin.sym} 2542 20870 0 1 {name=l1110_5 lab=VSS}
C {./clkinv_1.sym} 2835 20850 0 0 {name=Xn_1052}
N 2743 20830 2723 20830 {lab=out_cas_int_b22}
C {./lab_pin.sym} 2723 20830 0 0 {name=l1111_0 lab=out_cas_int_b22}
N 2743 20850 2723 20850 {lab=n_0495}
C {./lab_pin.sym} 2723 20850 0 0 {name=l1111_1 lab=n_0495}
N 2743 20870 2723 20870 {lab=VDD}
C {./lab_pin.sym} 2723 20870 0 0 {name=l1111_2 lab=VDD}
N 2927 20830 2947 20830 {lab=VDD}
C {./lab_pin.sym} 2947 20830 0 1 {name=l1111_3 lab=VDD}
N 2927 20850 2947 20850 {lab=VSS}
C {./lab_pin.sym} 2947 20850 0 1 {name=l1111_4 lab=VSS}
N 2927 20870 2947 20870 {lab=VSS}
C {./lab_pin.sym} 2947 20870 0 1 {name=l1111_5 lab=VSS}
C {./clkinv_1.sym} 3240 20850 0 0 {name=Xn_1053}
N 3148 20830 3128 20830 {lab=out_cas_int_b23}
C {./lab_pin.sym} 3128 20830 0 0 {name=l1112_0 lab=out_cas_int_b23}
N 3148 20850 3128 20850 {lab=n_0496}
C {./lab_pin.sym} 3128 20850 0 0 {name=l1112_1 lab=n_0496}
N 3148 20870 3128 20870 {lab=VDD}
C {./lab_pin.sym} 3128 20870 0 0 {name=l1112_2 lab=VDD}
N 3332 20830 3352 20830 {lab=VDD}
C {./lab_pin.sym} 3352 20830 0 1 {name=l1112_3 lab=VDD}
N 3332 20850 3352 20850 {lab=VSS}
C {./lab_pin.sym} 3352 20850 0 1 {name=l1112_4 lab=VSS}
N 3332 20870 3352 20870 {lab=VSS}
C {./lab_pin.sym} 3352 20870 0 1 {name=l1112_5 lab=VSS}
C {./clkinv_1.sym} 3645 20850 0 0 {name=Xn_1054}
N 3553 20830 3533 20830 {lab=u_cas_int_out_int1_b6}
C {./lab_pin.sym} 3533 20830 0 0 {name=l1113_0 lab=u_cas_int_out_int1_b6}
N 3553 20850 3533 20850 {lab=n_0497}
C {./lab_pin.sym} 3533 20850 0 0 {name=l1113_1 lab=n_0497}
N 3553 20870 3533 20870 {lab=VDD}
C {./lab_pin.sym} 3533 20870 0 0 {name=l1113_2 lab=VDD}
N 3737 20830 3757 20830 {lab=VDD}
C {./lab_pin.sym} 3757 20830 0 1 {name=l1113_3 lab=VDD}
N 3737 20850 3757 20850 {lab=VSS}
C {./lab_pin.sym} 3757 20850 0 1 {name=l1113_4 lab=VSS}
N 3737 20870 3757 20870 {lab=VSS}
C {./lab_pin.sym} 3757 20870 0 1 {name=l1113_5 lab=VSS}
C {./clkinv_1.sym} 4050 20850 0 0 {name=Xn_1055}
N 3958 20830 3938 20830 {lab=u_cas_int_out_int1_b7}
C {./lab_pin.sym} 3938 20830 0 0 {name=l1114_0 lab=u_cas_int_out_int1_b7}
N 3958 20850 3938 20850 {lab=n_0498}
C {./lab_pin.sym} 3938 20850 0 0 {name=l1114_1 lab=n_0498}
N 3958 20870 3938 20870 {lab=VDD}
C {./lab_pin.sym} 3938 20870 0 0 {name=l1114_2 lab=VDD}
N 4142 20830 4162 20830 {lab=VDD}
C {./lab_pin.sym} 4162 20830 0 1 {name=l1114_3 lab=VDD}
N 4142 20850 4162 20850 {lab=VSS}
C {./lab_pin.sym} 4162 20850 0 1 {name=l1114_4 lab=VSS}
N 4142 20870 4162 20870 {lab=VSS}
C {./lab_pin.sym} 4162 20870 0 1 {name=l1114_5 lab=VSS}
C {./clkinv_1.sym} 4455 20850 0 0 {name=Xn_1056}
N 4363 20830 4343 20830 {lab=u_cas_diff_u_diff3_in_min1_b13}
C {./lab_pin.sym} 4343 20830 0 0 {name=l1115_0 lab=u_cas_diff_u_diff3_in_min1_b13}
N 4363 20850 4343 20850 {lab=n_0499}
C {./lab_pin.sym} 4343 20850 0 0 {name=l1115_1 lab=n_0499}
N 4363 20870 4343 20870 {lab=VDD}
C {./lab_pin.sym} 4343 20870 0 0 {name=l1115_2 lab=VDD}
N 4547 20830 4567 20830 {lab=VDD}
C {./lab_pin.sym} 4567 20830 0 1 {name=l1115_3 lab=VDD}
N 4547 20850 4567 20850 {lab=VSS}
C {./lab_pin.sym} 4567 20850 0 1 {name=l1115_4 lab=VSS}
N 4547 20870 4567 20870 {lab=VSS}
C {./lab_pin.sym} 4567 20870 0 1 {name=l1115_5 lab=VSS}
C {./clkinv_1.sym} 0 21075 0 0 {name=Xn_1057}
N -92 21055 -112 21055 {lab=u_cas_diff_u_diff3_in_min1_b12}
C {./lab_pin.sym} -112 21055 0 0 {name=l1116_0 lab=u_cas_diff_u_diff3_in_min1_b12}
N -92 21075 -112 21075 {lab=n_0500}
C {./lab_pin.sym} -112 21075 0 0 {name=l1116_1 lab=n_0500}
N -92 21095 -112 21095 {lab=VDD}
C {./lab_pin.sym} -112 21095 0 0 {name=l1116_2 lab=VDD}
N 92 21055 112 21055 {lab=VDD}
C {./lab_pin.sym} 112 21055 0 1 {name=l1116_3 lab=VDD}
N 92 21075 112 21075 {lab=VSS}
C {./lab_pin.sym} 112 21075 0 1 {name=l1116_4 lab=VSS}
N 92 21095 112 21095 {lab=VSS}
C {./lab_pin.sym} 112 21095 0 1 {name=l1116_5 lab=VSS}
C {./clkinv_1.sym} 405 21075 0 0 {name=Xn_1058}
N 313 21055 293 21055 {lab=u_cas_diff_u_diff3_in_min1_b11}
C {./lab_pin.sym} 293 21055 0 0 {name=l1117_0 lab=u_cas_diff_u_diff3_in_min1_b11}
N 313 21075 293 21075 {lab=n_0501}
C {./lab_pin.sym} 293 21075 0 0 {name=l1117_1 lab=n_0501}
N 313 21095 293 21095 {lab=VDD}
C {./lab_pin.sym} 293 21095 0 0 {name=l1117_2 lab=VDD}
N 497 21055 517 21055 {lab=VDD}
C {./lab_pin.sym} 517 21055 0 1 {name=l1117_3 lab=VDD}
N 497 21075 517 21075 {lab=VSS}
C {./lab_pin.sym} 517 21075 0 1 {name=l1117_4 lab=VSS}
N 497 21095 517 21095 {lab=VSS}
C {./lab_pin.sym} 517 21095 0 1 {name=l1117_5 lab=VSS}
C {./clkinv_1.sym} 810 21075 0 0 {name=Xn_1059}
N 718 21055 698 21055 {lab=u_cas_diff_u_diff3_in_min1_b10}
C {./lab_pin.sym} 698 21055 0 0 {name=l1118_0 lab=u_cas_diff_u_diff3_in_min1_b10}
N 718 21075 698 21075 {lab=n_0502}
C {./lab_pin.sym} 698 21075 0 0 {name=l1118_1 lab=n_0502}
N 718 21095 698 21095 {lab=VDD}
C {./lab_pin.sym} 698 21095 0 0 {name=l1118_2 lab=VDD}
N 902 21055 922 21055 {lab=VDD}
C {./lab_pin.sym} 922 21055 0 1 {name=l1118_3 lab=VDD}
N 902 21075 922 21075 {lab=VSS}
C {./lab_pin.sym} 922 21075 0 1 {name=l1118_4 lab=VSS}
N 902 21095 922 21095 {lab=VSS}
C {./lab_pin.sym} 922 21095 0 1 {name=l1118_5 lab=VSS}
C {./clkinv_1.sym} 1215 21075 0 0 {name=Xn_1060}
N 1123 21055 1103 21055 {lab=u_cas_diff_u_diff3_in_min1_b9}
C {./lab_pin.sym} 1103 21055 0 0 {name=l1119_0 lab=u_cas_diff_u_diff3_in_min1_b9}
N 1123 21075 1103 21075 {lab=n_0503}
C {./lab_pin.sym} 1103 21075 0 0 {name=l1119_1 lab=n_0503}
N 1123 21095 1103 21095 {lab=VDD}
C {./lab_pin.sym} 1103 21095 0 0 {name=l1119_2 lab=VDD}
N 1307 21055 1327 21055 {lab=VDD}
C {./lab_pin.sym} 1327 21055 0 1 {name=l1119_3 lab=VDD}
N 1307 21075 1327 21075 {lab=VSS}
C {./lab_pin.sym} 1327 21075 0 1 {name=l1119_4 lab=VSS}
N 1307 21095 1327 21095 {lab=VSS}
C {./lab_pin.sym} 1327 21095 0 1 {name=l1119_5 lab=VSS}
C {./clkinv_1.sym} 1620 21075 0 0 {name=Xn_1061}
N 1528 21055 1508 21055 {lab=u_cas_diff_u_diff3_in_min1_b8}
C {./lab_pin.sym} 1508 21055 0 0 {name=l1120_0 lab=u_cas_diff_u_diff3_in_min1_b8}
N 1528 21075 1508 21075 {lab=n_0504}
C {./lab_pin.sym} 1508 21075 0 0 {name=l1120_1 lab=n_0504}
N 1528 21095 1508 21095 {lab=VDD}
C {./lab_pin.sym} 1508 21095 0 0 {name=l1120_2 lab=VDD}
N 1712 21055 1732 21055 {lab=VDD}
C {./lab_pin.sym} 1732 21055 0 1 {name=l1120_3 lab=VDD}
N 1712 21075 1732 21075 {lab=VSS}
C {./lab_pin.sym} 1732 21075 0 1 {name=l1120_4 lab=VSS}
N 1712 21095 1732 21095 {lab=VSS}
C {./lab_pin.sym} 1732 21095 0 1 {name=l1120_5 lab=VSS}
C {./clkinv_1.sym} 2025 21075 0 0 {name=Xn_1062}
N 1933 21055 1913 21055 {lab=u_cas_diff_out_diff2_b7}
C {./lab_pin.sym} 1913 21055 0 0 {name=l1121_0 lab=u_cas_diff_out_diff2_b7}
N 1933 21075 1913 21075 {lab=n_0505}
C {./lab_pin.sym} 1913 21075 0 0 {name=l1121_1 lab=n_0505}
N 1933 21095 1913 21095 {lab=VDD}
C {./lab_pin.sym} 1913 21095 0 0 {name=l1121_2 lab=VDD}
N 2117 21055 2137 21055 {lab=VDD}
C {./lab_pin.sym} 2137 21055 0 1 {name=l1121_3 lab=VDD}
N 2117 21075 2137 21075 {lab=VSS}
C {./lab_pin.sym} 2137 21075 0 1 {name=l1121_4 lab=VSS}
N 2117 21095 2137 21095 {lab=VSS}
C {./lab_pin.sym} 2137 21095 0 1 {name=l1121_5 lab=VSS}
C {./clkinv_1.sym} 2430 21075 0 0 {name=Xn_1063}
N 2338 21055 2318 21055 {lab=u_cas_diff_u_diff3_in_min1_b7}
C {./lab_pin.sym} 2318 21055 0 0 {name=l1122_0 lab=u_cas_diff_u_diff3_in_min1_b7}
N 2338 21075 2318 21075 {lab=n_0506}
C {./lab_pin.sym} 2318 21075 0 0 {name=l1122_1 lab=n_0506}
N 2338 21095 2318 21095 {lab=VDD}
C {./lab_pin.sym} 2318 21095 0 0 {name=l1122_2 lab=VDD}
N 2522 21055 2542 21055 {lab=VDD}
C {./lab_pin.sym} 2542 21055 0 1 {name=l1122_3 lab=VDD}
N 2522 21075 2542 21075 {lab=VSS}
C {./lab_pin.sym} 2542 21075 0 1 {name=l1122_4 lab=VSS}
N 2522 21095 2542 21095 {lab=VSS}
C {./lab_pin.sym} 2542 21095 0 1 {name=l1122_5 lab=VSS}
C {./clkinv_1.sym} 2835 21075 0 0 {name=Xn_1064}
N 2743 21055 2723 21055 {lab=u_cas_diff_u_diff3_in_min1_b6}
C {./lab_pin.sym} 2723 21055 0 0 {name=l1123_0 lab=u_cas_diff_u_diff3_in_min1_b6}
N 2743 21075 2723 21075 {lab=n_0507}
C {./lab_pin.sym} 2723 21075 0 0 {name=l1123_1 lab=n_0507}
N 2743 21095 2723 21095 {lab=VDD}
C {./lab_pin.sym} 2723 21095 0 0 {name=l1123_2 lab=VDD}
N 2927 21055 2947 21055 {lab=VDD}
C {./lab_pin.sym} 2947 21055 0 1 {name=l1123_3 lab=VDD}
N 2927 21075 2947 21075 {lab=VSS}
C {./lab_pin.sym} 2947 21075 0 1 {name=l1123_4 lab=VSS}
N 2927 21095 2947 21095 {lab=VSS}
C {./lab_pin.sym} 2947 21095 0 1 {name=l1123_5 lab=VSS}
C {./clkinv_1.sym} 3240 21075 0 0 {name=Xn_1065}
N 3148 21055 3128 21055 {lab=u_cas_diff_out_diff2_b6}
C {./lab_pin.sym} 3128 21055 0 0 {name=l1124_0 lab=u_cas_diff_out_diff2_b6}
N 3148 21075 3128 21075 {lab=n_0508}
C {./lab_pin.sym} 3128 21075 0 0 {name=l1124_1 lab=n_0508}
N 3148 21095 3128 21095 {lab=VDD}
C {./lab_pin.sym} 3128 21095 0 0 {name=l1124_2 lab=VDD}
N 3332 21055 3352 21055 {lab=VDD}
C {./lab_pin.sym} 3352 21055 0 1 {name=l1124_3 lab=VDD}
N 3332 21075 3352 21075 {lab=VSS}
C {./lab_pin.sym} 3352 21075 0 1 {name=l1124_4 lab=VSS}
N 3332 21095 3352 21095 {lab=VSS}
C {./lab_pin.sym} 3352 21095 0 1 {name=l1124_5 lab=VSS}
C {./clkinv_1.sym} 3645 21075 0 0 {name=Xn_1066}
N 3553 21055 3533 21055 {lab=u_cas_diff_u_diff3_in_min1_b5}
C {./lab_pin.sym} 3533 21055 0 0 {name=l1125_0 lab=u_cas_diff_u_diff3_in_min1_b5}
N 3553 21075 3533 21075 {lab=n_0509}
C {./lab_pin.sym} 3533 21075 0 0 {name=l1125_1 lab=n_0509}
N 3553 21095 3533 21095 {lab=VDD}
C {./lab_pin.sym} 3533 21095 0 0 {name=l1125_2 lab=VDD}
N 3737 21055 3757 21055 {lab=VDD}
C {./lab_pin.sym} 3757 21055 0 1 {name=l1125_3 lab=VDD}
N 3737 21075 3757 21075 {lab=VSS}
C {./lab_pin.sym} 3757 21075 0 1 {name=l1125_4 lab=VSS}
N 3737 21095 3757 21095 {lab=VSS}
C {./lab_pin.sym} 3757 21095 0 1 {name=l1125_5 lab=VSS}
C {./clkinv_1.sym} 4050 21075 0 0 {name=Xn_1067}
N 3958 21055 3938 21055 {lab=u_cas_diff_out_diff2_b5}
C {./lab_pin.sym} 3938 21055 0 0 {name=l1126_0 lab=u_cas_diff_out_diff2_b5}
N 3958 21075 3938 21075 {lab=n_0510}
C {./lab_pin.sym} 3938 21075 0 0 {name=l1126_1 lab=n_0510}
N 3958 21095 3938 21095 {lab=VDD}
C {./lab_pin.sym} 3938 21095 0 0 {name=l1126_2 lab=VDD}
N 4142 21055 4162 21055 {lab=VDD}
C {./lab_pin.sym} 4162 21055 0 1 {name=l1126_3 lab=VDD}
N 4142 21075 4162 21075 {lab=VSS}
C {./lab_pin.sym} 4162 21075 0 1 {name=l1126_4 lab=VSS}
N 4142 21095 4162 21095 {lab=VSS}
C {./lab_pin.sym} 4162 21095 0 1 {name=l1126_5 lab=VSS}
C {./clkinv_1.sym} 4455 21075 0 0 {name=Xn_1068}
N 4363 21055 4343 21055 {lab=u_cas_diff_u_diff3_in_min1_b4}
C {./lab_pin.sym} 4343 21055 0 0 {name=l1127_0 lab=u_cas_diff_u_diff3_in_min1_b4}
N 4363 21075 4343 21075 {lab=n_0511}
C {./lab_pin.sym} 4343 21075 0 0 {name=l1127_1 lab=n_0511}
N 4363 21095 4343 21095 {lab=VDD}
C {./lab_pin.sym} 4343 21095 0 0 {name=l1127_2 lab=VDD}
N 4547 21055 4567 21055 {lab=VDD}
C {./lab_pin.sym} 4567 21055 0 1 {name=l1127_3 lab=VDD}
N 4547 21075 4567 21075 {lab=VSS}
C {./lab_pin.sym} 4567 21075 0 1 {name=l1127_4 lab=VSS}
N 4547 21095 4567 21095 {lab=VSS}
C {./lab_pin.sym} 4567 21095 0 1 {name=l1127_5 lab=VSS}
C {./clkinv_1.sym} 0 21300 0 0 {name=Xn_1069}
N -92 21280 -112 21280 {lab=u_cas_diff_u_diff3_in_min1_b3}
C {./lab_pin.sym} -112 21280 0 0 {name=l1128_0 lab=u_cas_diff_u_diff3_in_min1_b3}
N -92 21300 -112 21300 {lab=n_0512}
C {./lab_pin.sym} -112 21300 0 0 {name=l1128_1 lab=n_0512}
N -92 21320 -112 21320 {lab=VDD}
C {./lab_pin.sym} -112 21320 0 0 {name=l1128_2 lab=VDD}
N 92 21280 112 21280 {lab=VDD}
C {./lab_pin.sym} 112 21280 0 1 {name=l1128_3 lab=VDD}
N 92 21300 112 21300 {lab=VSS}
C {./lab_pin.sym} 112 21300 0 1 {name=l1128_4 lab=VSS}
N 92 21320 112 21320 {lab=VSS}
C {./lab_pin.sym} 112 21320 0 1 {name=l1128_5 lab=VSS}
C {./clkinv_1.sym} 405 21300 0 0 {name=Xn_1070}
N 313 21280 293 21280 {lab=u_cas_diff_out_diff2_b3}
C {./lab_pin.sym} 293 21280 0 0 {name=l1129_0 lab=u_cas_diff_out_diff2_b3}
N 313 21300 293 21300 {lab=n_0513}
C {./lab_pin.sym} 293 21300 0 0 {name=l1129_1 lab=n_0513}
N 313 21320 293 21320 {lab=VDD}
C {./lab_pin.sym} 293 21320 0 0 {name=l1129_2 lab=VDD}
N 497 21280 517 21280 {lab=VDD}
C {./lab_pin.sym} 517 21280 0 1 {name=l1129_3 lab=VDD}
N 497 21300 517 21300 {lab=VSS}
C {./lab_pin.sym} 517 21300 0 1 {name=l1129_4 lab=VSS}
N 497 21320 517 21320 {lab=VSS}
C {./lab_pin.sym} 517 21320 0 1 {name=l1129_5 lab=VSS}
C {./clkinv_1.sym} 810 21300 0 0 {name=Xn_1071}
N 718 21280 698 21280 {lab=u_cas_diff_u_diff3_in_min1_b2}
C {./lab_pin.sym} 698 21280 0 0 {name=l1130_0 lab=u_cas_diff_u_diff3_in_min1_b2}
N 718 21300 698 21300 {lab=n_0514}
C {./lab_pin.sym} 698 21300 0 0 {name=l1130_1 lab=n_0514}
N 718 21320 698 21320 {lab=VDD}
C {./lab_pin.sym} 698 21320 0 0 {name=l1130_2 lab=VDD}
N 902 21280 922 21280 {lab=VDD}
C {./lab_pin.sym} 922 21280 0 1 {name=l1130_3 lab=VDD}
N 902 21300 922 21300 {lab=VSS}
C {./lab_pin.sym} 922 21300 0 1 {name=l1130_4 lab=VSS}
N 902 21320 922 21320 {lab=VSS}
C {./lab_pin.sym} 922 21320 0 1 {name=l1130_5 lab=VSS}
C {./clkinv_1.sym} 1215 21300 0 0 {name=Xn_1072}
N 1123 21280 1103 21280 {lab=u_cas_diff_u_diff3_in_min1_b1}
C {./lab_pin.sym} 1103 21280 0 0 {name=l1131_0 lab=u_cas_diff_u_diff3_in_min1_b1}
N 1123 21300 1103 21300 {lab=n_0515}
C {./lab_pin.sym} 1103 21300 0 0 {name=l1131_1 lab=n_0515}
N 1123 21320 1103 21320 {lab=VDD}
C {./lab_pin.sym} 1103 21320 0 0 {name=l1131_2 lab=VDD}
N 1307 21280 1327 21280 {lab=VDD}
C {./lab_pin.sym} 1327 21280 0 1 {name=l1131_3 lab=VDD}
N 1307 21300 1327 21300 {lab=VSS}
C {./lab_pin.sym} 1327 21300 0 1 {name=l1131_4 lab=VSS}
N 1307 21320 1327 21320 {lab=VSS}
C {./lab_pin.sym} 1327 21320 0 1 {name=l1131_5 lab=VSS}
C {./clkinv_1.sym} 1620 21300 0 0 {name=Xn_1073}
N 1528 21280 1508 21280 {lab=u_cas_diff_u_diff3_in_min1_b0}
C {./lab_pin.sym} 1508 21280 0 0 {name=l1132_0 lab=u_cas_diff_u_diff3_in_min1_b0}
N 1528 21300 1508 21300 {lab=n_0516}
C {./lab_pin.sym} 1508 21300 0 0 {name=l1132_1 lab=n_0516}
N 1528 21320 1508 21320 {lab=VDD}
C {./lab_pin.sym} 1508 21320 0 0 {name=l1132_2 lab=VDD}
N 1712 21280 1732 21280 {lab=VDD}
C {./lab_pin.sym} 1732 21280 0 1 {name=l1132_3 lab=VDD}
N 1712 21300 1732 21300 {lab=VSS}
C {./lab_pin.sym} 1732 21300 0 1 {name=l1132_4 lab=VSS}
N 1712 21320 1732 21320 {lab=VSS}
C {./lab_pin.sym} 1732 21320 0 1 {name=l1132_5 lab=VSS}
C {./clkinv_1.sym} 2025 21300 0 0 {name=Xn_1074}
N 1933 21280 1913 21280 {lab=u_cas_diff_out_diff2_b14}
C {./lab_pin.sym} 1913 21280 0 0 {name=l1133_0 lab=u_cas_diff_out_diff2_b14}
N 1933 21300 1913 21300 {lab=n_0517}
C {./lab_pin.sym} 1913 21300 0 0 {name=l1133_1 lab=n_0517}
N 1933 21320 1913 21320 {lab=VDD}
C {./lab_pin.sym} 1913 21320 0 0 {name=l1133_2 lab=VDD}
N 2117 21280 2137 21280 {lab=VDD}
C {./lab_pin.sym} 2137 21280 0 1 {name=l1133_3 lab=VDD}
N 2117 21300 2137 21300 {lab=VSS}
C {./lab_pin.sym} 2137 21300 0 1 {name=l1133_4 lab=VSS}
N 2117 21320 2137 21320 {lab=VSS}
C {./lab_pin.sym} 2137 21320 0 1 {name=l1133_5 lab=VSS}
C {./clkinv_1.sym} 2430 21300 0 0 {name=Xn_1075}
N 2338 21280 2318 21280 {lab=u_cas_diff_out_diff2_b15}
C {./lab_pin.sym} 2318 21280 0 0 {name=l1134_0 lab=u_cas_diff_out_diff2_b15}
N 2338 21300 2318 21300 {lab=n_0518}
C {./lab_pin.sym} 2318 21300 0 0 {name=l1134_1 lab=n_0518}
N 2338 21320 2318 21320 {lab=VDD}
C {./lab_pin.sym} 2318 21320 0 0 {name=l1134_2 lab=VDD}
N 2522 21280 2542 21280 {lab=VDD}
C {./lab_pin.sym} 2542 21280 0 1 {name=l1134_3 lab=VDD}
N 2522 21300 2542 21300 {lab=VSS}
C {./lab_pin.sym} 2542 21300 0 1 {name=l1134_4 lab=VSS}
N 2522 21320 2542 21320 {lab=VSS}
C {./lab_pin.sym} 2542 21320 0 1 {name=l1134_5 lab=VSS}
C {./clkinv_1.sym} 2835 21300 0 0 {name=Xn_1076}
N 2743 21280 2723 21280 {lab=u_cas_diff_out_diff2_b16}
C {./lab_pin.sym} 2723 21280 0 0 {name=l1135_0 lab=u_cas_diff_out_diff2_b16}
N 2743 21300 2723 21300 {lab=n_0519}
C {./lab_pin.sym} 2723 21300 0 0 {name=l1135_1 lab=n_0519}
N 2743 21320 2723 21320 {lab=VDD}
C {./lab_pin.sym} 2723 21320 0 0 {name=l1135_2 lab=VDD}
N 2927 21280 2947 21280 {lab=VDD}
C {./lab_pin.sym} 2947 21280 0 1 {name=l1135_3 lab=VDD}
N 2927 21300 2947 21300 {lab=VSS}
C {./lab_pin.sym} 2947 21300 0 1 {name=l1135_4 lab=VSS}
N 2927 21320 2947 21320 {lab=VSS}
C {./lab_pin.sym} 2947 21320 0 1 {name=l1135_5 lab=VSS}
C {./clkinv_1.sym} 3240 21300 0 0 {name=Xn_1077}
N 3148 21280 3128 21280 {lab=u_cas_diff_out_diff2_b17}
C {./lab_pin.sym} 3128 21280 0 0 {name=l1136_0 lab=u_cas_diff_out_diff2_b17}
N 3148 21300 3128 21300 {lab=n_0520}
C {./lab_pin.sym} 3128 21300 0 0 {name=l1136_1 lab=n_0520}
N 3148 21320 3128 21320 {lab=VDD}
C {./lab_pin.sym} 3128 21320 0 0 {name=l1136_2 lab=VDD}
N 3332 21280 3352 21280 {lab=VDD}
C {./lab_pin.sym} 3352 21280 0 1 {name=l1136_3 lab=VDD}
N 3332 21300 3352 21300 {lab=VSS}
C {./lab_pin.sym} 3352 21300 0 1 {name=l1136_4 lab=VSS}
N 3332 21320 3352 21320 {lab=VSS}
C {./lab_pin.sym} 3352 21320 0 1 {name=l1136_5 lab=VSS}
C {./clkinv_1.sym} 3645 21300 0 0 {name=Xn_1078}
N 3553 21280 3533 21280 {lab=u_cas_diff_out_diff2_b18}
C {./lab_pin.sym} 3533 21280 0 0 {name=l1137_0 lab=u_cas_diff_out_diff2_b18}
N 3553 21300 3533 21300 {lab=n_0521}
C {./lab_pin.sym} 3533 21300 0 0 {name=l1137_1 lab=n_0521}
N 3553 21320 3533 21320 {lab=VDD}
C {./lab_pin.sym} 3533 21320 0 0 {name=l1137_2 lab=VDD}
N 3737 21280 3757 21280 {lab=VDD}
C {./lab_pin.sym} 3757 21280 0 1 {name=l1137_3 lab=VDD}
N 3737 21300 3757 21300 {lab=VSS}
C {./lab_pin.sym} 3757 21300 0 1 {name=l1137_4 lab=VSS}
N 3737 21320 3757 21320 {lab=VSS}
C {./lab_pin.sym} 3757 21320 0 1 {name=l1137_5 lab=VSS}
C {./clkinv_1.sym} 4050 21300 0 0 {name=Xn_1079}
N 3958 21280 3938 21280 {lab=u_cas_diff_out_diff2_b19}
C {./lab_pin.sym} 3938 21280 0 0 {name=l1138_0 lab=u_cas_diff_out_diff2_b19}
N 3958 21300 3938 21300 {lab=n_0522}
C {./lab_pin.sym} 3938 21300 0 0 {name=l1138_1 lab=n_0522}
N 3958 21320 3938 21320 {lab=VDD}
C {./lab_pin.sym} 3938 21320 0 0 {name=l1138_2 lab=VDD}
N 4142 21280 4162 21280 {lab=VDD}
C {./lab_pin.sym} 4162 21280 0 1 {name=l1138_3 lab=VDD}
N 4142 21300 4162 21300 {lab=VSS}
C {./lab_pin.sym} 4162 21300 0 1 {name=l1138_4 lab=VSS}
N 4142 21320 4162 21320 {lab=VSS}
C {./lab_pin.sym} 4162 21320 0 1 {name=l1138_5 lab=VSS}
C {./clkinv_1.sym} 4455 21300 0 0 {name=Xn_1080}
N 4363 21280 4343 21280 {lab=u_cas_diff_out_diff2_b20}
C {./lab_pin.sym} 4343 21280 0 0 {name=l1139_0 lab=u_cas_diff_out_diff2_b20}
N 4363 21300 4343 21300 {lab=n_0523}
C {./lab_pin.sym} 4343 21300 0 0 {name=l1139_1 lab=n_0523}
N 4363 21320 4343 21320 {lab=VDD}
C {./lab_pin.sym} 4343 21320 0 0 {name=l1139_2 lab=VDD}
N 4547 21280 4567 21280 {lab=VDD}
C {./lab_pin.sym} 4567 21280 0 1 {name=l1139_3 lab=VDD}
N 4547 21300 4567 21300 {lab=VSS}
C {./lab_pin.sym} 4567 21300 0 1 {name=l1139_4 lab=VSS}
N 4547 21320 4567 21320 {lab=VSS}
C {./lab_pin.sym} 4567 21320 0 1 {name=l1139_5 lab=VSS}
C {./clkinv_1.sym} 0 21525 0 0 {name=Xn_1081}
N -92 21505 -112 21505 {lab=u_cas_diff_u_diff3_in_min1_b21}
C {./lab_pin.sym} -112 21505 0 0 {name=l1140_0 lab=u_cas_diff_u_diff3_in_min1_b21}
N -92 21525 -112 21525 {lab=n_0524}
C {./lab_pin.sym} -112 21525 0 0 {name=l1140_1 lab=n_0524}
N -92 21545 -112 21545 {lab=VDD}
C {./lab_pin.sym} -112 21545 0 0 {name=l1140_2 lab=VDD}
N 92 21505 112 21505 {lab=VDD}
C {./lab_pin.sym} 112 21505 0 1 {name=l1140_3 lab=VDD}
N 92 21525 112 21525 {lab=VSS}
C {./lab_pin.sym} 112 21525 0 1 {name=l1140_4 lab=VSS}
N 92 21545 112 21545 {lab=VSS}
C {./lab_pin.sym} 112 21545 0 1 {name=l1140_5 lab=VSS}
C {./clkinv_1.sym} 405 21525 0 0 {name=Xn_1082}
N 313 21505 293 21505 {lab=u_cas_diff_u_diff3_in_min1_b22}
C {./lab_pin.sym} 293 21505 0 0 {name=l1141_0 lab=u_cas_diff_u_diff3_in_min1_b22}
N 313 21525 293 21525 {lab=n_0525}
C {./lab_pin.sym} 293 21525 0 0 {name=l1141_1 lab=n_0525}
N 313 21545 293 21545 {lab=VDD}
C {./lab_pin.sym} 293 21545 0 0 {name=l1141_2 lab=VDD}
N 497 21505 517 21505 {lab=VDD}
C {./lab_pin.sym} 517 21505 0 1 {name=l1141_3 lab=VDD}
N 497 21525 517 21525 {lab=VSS}
C {./lab_pin.sym} 517 21525 0 1 {name=l1141_4 lab=VSS}
N 497 21545 517 21545 {lab=VSS}
C {./lab_pin.sym} 517 21545 0 1 {name=l1141_5 lab=VSS}
C {./clkinv_1.sym} 810 21525 0 0 {name=Xn_1083}
N 718 21505 698 21505 {lab=u_cas_diff_out_diff2_b23}
C {./lab_pin.sym} 698 21505 0 0 {name=l1142_0 lab=u_cas_diff_out_diff2_b23}
N 718 21525 698 21525 {lab=n_0526}
C {./lab_pin.sym} 698 21525 0 0 {name=l1142_1 lab=n_0526}
N 718 21545 698 21545 {lab=VDD}
C {./lab_pin.sym} 698 21545 0 0 {name=l1142_2 lab=VDD}
N 902 21505 922 21505 {lab=VDD}
C {./lab_pin.sym} 922 21505 0 1 {name=l1142_3 lab=VDD}
N 902 21525 922 21525 {lab=VSS}
C {./lab_pin.sym} 922 21525 0 1 {name=l1142_4 lab=VSS}
N 902 21545 922 21545 {lab=VSS}
C {./lab_pin.sym} 922 21545 0 1 {name=l1142_5 lab=VSS}
C {./clkinv_1.sym} 1215 21525 0 0 {name=Xn_1084}
N 1123 21505 1103 21505 {lab=u_cas_diff_out_diff1_b1}
C {./lab_pin.sym} 1103 21505 0 0 {name=l1143_0 lab=u_cas_diff_out_diff1_b1}
N 1123 21525 1103 21525 {lab=n_0527}
C {./lab_pin.sym} 1103 21525 0 0 {name=l1143_1 lab=n_0527}
N 1123 21545 1103 21545 {lab=VDD}
C {./lab_pin.sym} 1103 21545 0 0 {name=l1143_2 lab=VDD}
N 1307 21505 1327 21505 {lab=VDD}
C {./lab_pin.sym} 1327 21505 0 1 {name=l1143_3 lab=VDD}
N 1307 21525 1327 21525 {lab=VSS}
C {./lab_pin.sym} 1327 21525 0 1 {name=l1143_4 lab=VSS}
N 1307 21545 1327 21545 {lab=VSS}
C {./lab_pin.sym} 1327 21545 0 1 {name=l1143_5 lab=VSS}
C {./clkinv_1.sym} 1620 21525 0 0 {name=Xn_1085}
N 1528 21505 1508 21505 {lab=u_cas_diff_out_diff1_b0}
C {./lab_pin.sym} 1508 21505 0 0 {name=l1144_0 lab=u_cas_diff_out_diff1_b0}
N 1528 21525 1508 21525 {lab=n_0528}
C {./lab_pin.sym} 1508 21525 0 0 {name=l1144_1 lab=n_0528}
N 1528 21545 1508 21545 {lab=VDD}
C {./lab_pin.sym} 1508 21545 0 0 {name=l1144_2 lab=VDD}
N 1712 21505 1732 21505 {lab=VDD}
C {./lab_pin.sym} 1732 21505 0 1 {name=l1144_3 lab=VDD}
N 1712 21525 1732 21525 {lab=VSS}
C {./lab_pin.sym} 1732 21525 0 1 {name=l1144_4 lab=VSS}
N 1712 21545 1732 21545 {lab=VSS}
C {./lab_pin.sym} 1732 21545 0 1 {name=l1144_5 lab=VSS}
C {./clkinv_1.sym} 2025 21525 0 0 {name=Xn_1086}
N 1933 21505 1913 21505 {lab=u_cas_diff_u_diff2_in_min1_b2}
C {./lab_pin.sym} 1913 21505 0 0 {name=l1145_0 lab=u_cas_diff_u_diff2_in_min1_b2}
N 1933 21525 1913 21525 {lab=n_0529}
C {./lab_pin.sym} 1913 21525 0 0 {name=l1145_1 lab=n_0529}
N 1933 21545 1913 21545 {lab=VDD}
C {./lab_pin.sym} 1913 21545 0 0 {name=l1145_2 lab=VDD}
N 2117 21505 2137 21505 {lab=VDD}
C {./lab_pin.sym} 2137 21505 0 1 {name=l1145_3 lab=VDD}
N 2117 21525 2137 21525 {lab=VSS}
C {./lab_pin.sym} 2137 21525 0 1 {name=l1145_4 lab=VSS}
N 2117 21545 2137 21545 {lab=VSS}
C {./lab_pin.sym} 2137 21545 0 1 {name=l1145_5 lab=VSS}
C {./clkinv_1.sym} 2430 21525 0 0 {name=Xn_1087}
N 2338 21505 2318 21505 {lab=u_cas_diff_out_diff1_b2}
C {./lab_pin.sym} 2318 21505 0 0 {name=l1146_0 lab=u_cas_diff_out_diff1_b2}
N 2338 21525 2318 21525 {lab=n_0530}
C {./lab_pin.sym} 2318 21525 0 0 {name=l1146_1 lab=n_0530}
N 2338 21545 2318 21545 {lab=VDD}
C {./lab_pin.sym} 2318 21545 0 0 {name=l1146_2 lab=VDD}
N 2522 21505 2542 21505 {lab=VDD}
C {./lab_pin.sym} 2542 21505 0 1 {name=l1146_3 lab=VDD}
N 2522 21525 2542 21525 {lab=VSS}
C {./lab_pin.sym} 2542 21525 0 1 {name=l1146_4 lab=VSS}
N 2522 21545 2542 21545 {lab=VSS}
C {./lab_pin.sym} 2542 21545 0 1 {name=l1146_5 lab=VSS}
C {./clkinv_1.sym} 2835 21525 0 0 {name=Xn_1088}
N 2743 21505 2723 21505 {lab=u_cas_diff_u_diff2_in_min1_b3}
C {./lab_pin.sym} 2723 21505 0 0 {name=l1147_0 lab=u_cas_diff_u_diff2_in_min1_b3}
N 2743 21525 2723 21525 {lab=n_0531}
C {./lab_pin.sym} 2723 21525 0 0 {name=l1147_1 lab=n_0531}
N 2743 21545 2723 21545 {lab=VDD}
C {./lab_pin.sym} 2723 21545 0 0 {name=l1147_2 lab=VDD}
N 2927 21505 2947 21505 {lab=VDD}
C {./lab_pin.sym} 2947 21505 0 1 {name=l1147_3 lab=VDD}
N 2927 21525 2947 21525 {lab=VSS}
C {./lab_pin.sym} 2947 21525 0 1 {name=l1147_4 lab=VSS}
N 2927 21545 2947 21545 {lab=VSS}
C {./lab_pin.sym} 2947 21545 0 1 {name=l1147_5 lab=VSS}
C {./clkinv_1.sym} 3240 21525 0 0 {name=Xn_1089}
N 3148 21505 3128 21505 {lab=u_cas_diff_out_diff1_b3}
C {./lab_pin.sym} 3128 21505 0 0 {name=l1148_0 lab=u_cas_diff_out_diff1_b3}
N 3148 21525 3128 21525 {lab=n_0532}
C {./lab_pin.sym} 3128 21525 0 0 {name=l1148_1 lab=n_0532}
N 3148 21545 3128 21545 {lab=VDD}
C {./lab_pin.sym} 3128 21545 0 0 {name=l1148_2 lab=VDD}
N 3332 21505 3352 21505 {lab=VDD}
C {./lab_pin.sym} 3352 21505 0 1 {name=l1148_3 lab=VDD}
N 3332 21525 3352 21525 {lab=VSS}
C {./lab_pin.sym} 3352 21525 0 1 {name=l1148_4 lab=VSS}
N 3332 21545 3352 21545 {lab=VSS}
C {./lab_pin.sym} 3352 21545 0 1 {name=l1148_5 lab=VSS}
C {./clkinv_1.sym} 3645 21525 0 0 {name=Xn_1090}
N 3553 21505 3533 21505 {lab=u_cas_diff_u_diff2_in_min1_b4}
C {./lab_pin.sym} 3533 21505 0 0 {name=l1149_0 lab=u_cas_diff_u_diff2_in_min1_b4}
N 3553 21525 3533 21525 {lab=n_0533}
C {./lab_pin.sym} 3533 21525 0 0 {name=l1149_1 lab=n_0533}
N 3553 21545 3533 21545 {lab=VDD}
C {./lab_pin.sym} 3533 21545 0 0 {name=l1149_2 lab=VDD}
N 3737 21505 3757 21505 {lab=VDD}
C {./lab_pin.sym} 3757 21505 0 1 {name=l1149_3 lab=VDD}
N 3737 21525 3757 21525 {lab=VSS}
C {./lab_pin.sym} 3757 21525 0 1 {name=l1149_4 lab=VSS}
N 3737 21545 3757 21545 {lab=VSS}
C {./lab_pin.sym} 3757 21545 0 1 {name=l1149_5 lab=VSS}
C {./clkinv_1.sym} 4050 21525 0 0 {name=Xn_1091}
N 3958 21505 3938 21505 {lab=u_cas_diff_out_diff1_b4}
C {./lab_pin.sym} 3938 21505 0 0 {name=l1150_0 lab=u_cas_diff_out_diff1_b4}
N 3958 21525 3938 21525 {lab=n_0534}
C {./lab_pin.sym} 3938 21525 0 0 {name=l1150_1 lab=n_0534}
N 3958 21545 3938 21545 {lab=VDD}
C {./lab_pin.sym} 3938 21545 0 0 {name=l1150_2 lab=VDD}
N 4142 21505 4162 21505 {lab=VDD}
C {./lab_pin.sym} 4162 21505 0 1 {name=l1150_3 lab=VDD}
N 4142 21525 4162 21525 {lab=VSS}
C {./lab_pin.sym} 4162 21525 0 1 {name=l1150_4 lab=VSS}
N 4142 21545 4162 21545 {lab=VSS}
C {./lab_pin.sym} 4162 21545 0 1 {name=l1150_5 lab=VSS}
C {./clkinv_1.sym} 4455 21525 0 0 {name=Xn_1092}
N 4363 21505 4343 21505 {lab=u_cas_diff_u_diff2_in_min1_b5}
C {./lab_pin.sym} 4343 21505 0 0 {name=l1151_0 lab=u_cas_diff_u_diff2_in_min1_b5}
N 4363 21525 4343 21525 {lab=n_0535}
C {./lab_pin.sym} 4343 21525 0 0 {name=l1151_1 lab=n_0535}
N 4363 21545 4343 21545 {lab=VDD}
C {./lab_pin.sym} 4343 21545 0 0 {name=l1151_2 lab=VDD}
N 4547 21505 4567 21505 {lab=VDD}
C {./lab_pin.sym} 4567 21505 0 1 {name=l1151_3 lab=VDD}
N 4547 21525 4567 21525 {lab=VSS}
C {./lab_pin.sym} 4567 21525 0 1 {name=l1151_4 lab=VSS}
N 4547 21545 4567 21545 {lab=VSS}
C {./lab_pin.sym} 4567 21545 0 1 {name=l1151_5 lab=VSS}
C {./clkinv_1.sym} 0 21750 0 0 {name=Xn_1093}
N -92 21730 -112 21730 {lab=u_cas_diff_out_diff1_b5}
C {./lab_pin.sym} -112 21730 0 0 {name=l1152_0 lab=u_cas_diff_out_diff1_b5}
N -92 21750 -112 21750 {lab=n_0536}
C {./lab_pin.sym} -112 21750 0 0 {name=l1152_1 lab=n_0536}
N -92 21770 -112 21770 {lab=VDD}
C {./lab_pin.sym} -112 21770 0 0 {name=l1152_2 lab=VDD}
N 92 21730 112 21730 {lab=VDD}
C {./lab_pin.sym} 112 21730 0 1 {name=l1152_3 lab=VDD}
N 92 21750 112 21750 {lab=VSS}
C {./lab_pin.sym} 112 21750 0 1 {name=l1152_4 lab=VSS}
N 92 21770 112 21770 {lab=VSS}
C {./lab_pin.sym} 112 21770 0 1 {name=l1152_5 lab=VSS}
C {./clkinv_1.sym} 405 21750 0 0 {name=Xn_1094}
N 313 21730 293 21730 {lab=u_cas_diff_u_diff2_in_min1_b6}
C {./lab_pin.sym} 293 21730 0 0 {name=l1153_0 lab=u_cas_diff_u_diff2_in_min1_b6}
N 313 21750 293 21750 {lab=n_0537}
C {./lab_pin.sym} 293 21750 0 0 {name=l1153_1 lab=n_0537}
N 313 21770 293 21770 {lab=VDD}
C {./lab_pin.sym} 293 21770 0 0 {name=l1153_2 lab=VDD}
N 497 21730 517 21730 {lab=VDD}
C {./lab_pin.sym} 517 21730 0 1 {name=l1153_3 lab=VDD}
N 497 21750 517 21750 {lab=VSS}
C {./lab_pin.sym} 517 21750 0 1 {name=l1153_4 lab=VSS}
N 497 21770 517 21770 {lab=VSS}
C {./lab_pin.sym} 517 21770 0 1 {name=l1153_5 lab=VSS}
C {./clkinv_1.sym} 810 21750 0 0 {name=Xn_1095}
N 718 21730 698 21730 {lab=u_cas_diff_out_diff1_b6}
C {./lab_pin.sym} 698 21730 0 0 {name=l1154_0 lab=u_cas_diff_out_diff1_b6}
N 718 21750 698 21750 {lab=n_0538}
C {./lab_pin.sym} 698 21750 0 0 {name=l1154_1 lab=n_0538}
N 718 21770 698 21770 {lab=VDD}
C {./lab_pin.sym} 698 21770 0 0 {name=l1154_2 lab=VDD}
N 902 21730 922 21730 {lab=VDD}
C {./lab_pin.sym} 922 21730 0 1 {name=l1154_3 lab=VDD}
N 902 21750 922 21750 {lab=VSS}
C {./lab_pin.sym} 922 21750 0 1 {name=l1154_4 lab=VSS}
N 902 21770 922 21770 {lab=VSS}
C {./lab_pin.sym} 922 21770 0 1 {name=l1154_5 lab=VSS}
C {./clkinv_1.sym} 1215 21750 0 0 {name=Xn_1096}
N 1123 21730 1103 21730 {lab=u_cas_diff_u_diff2_in_min1_b7}
C {./lab_pin.sym} 1103 21730 0 0 {name=l1155_0 lab=u_cas_diff_u_diff2_in_min1_b7}
N 1123 21750 1103 21750 {lab=n_0539}
C {./lab_pin.sym} 1103 21750 0 0 {name=l1155_1 lab=n_0539}
N 1123 21770 1103 21770 {lab=VDD}
C {./lab_pin.sym} 1103 21770 0 0 {name=l1155_2 lab=VDD}
N 1307 21730 1327 21730 {lab=VDD}
C {./lab_pin.sym} 1327 21730 0 1 {name=l1155_3 lab=VDD}
N 1307 21750 1327 21750 {lab=VSS}
C {./lab_pin.sym} 1327 21750 0 1 {name=l1155_4 lab=VSS}
N 1307 21770 1327 21770 {lab=VSS}
C {./lab_pin.sym} 1327 21770 0 1 {name=l1155_5 lab=VSS}
C {./clkinv_1.sym} 1620 21750 0 0 {name=Xn_1097}
N 1528 21730 1508 21730 {lab=u_cas_diff_out_diff1_b7}
C {./lab_pin.sym} 1508 21730 0 0 {name=l1156_0 lab=u_cas_diff_out_diff1_b7}
N 1528 21750 1508 21750 {lab=n_0540}
C {./lab_pin.sym} 1508 21750 0 0 {name=l1156_1 lab=n_0540}
N 1528 21770 1508 21770 {lab=VDD}
C {./lab_pin.sym} 1508 21770 0 0 {name=l1156_2 lab=VDD}
N 1712 21730 1732 21730 {lab=VDD}
C {./lab_pin.sym} 1732 21730 0 1 {name=l1156_3 lab=VDD}
N 1712 21750 1732 21750 {lab=VSS}
C {./lab_pin.sym} 1732 21750 0 1 {name=l1156_4 lab=VSS}
N 1712 21770 1732 21770 {lab=VSS}
C {./lab_pin.sym} 1732 21770 0 1 {name=l1156_5 lab=VSS}
C {./clkinv_1.sym} 2025 21750 0 0 {name=Xn_1098}
N 1933 21730 1913 21730 {lab=u_cas_diff_u_diff2_in_min1_b8}
C {./lab_pin.sym} 1913 21730 0 0 {name=l1157_0 lab=u_cas_diff_u_diff2_in_min1_b8}
N 1933 21750 1913 21750 {lab=n_0541}
C {./lab_pin.sym} 1913 21750 0 0 {name=l1157_1 lab=n_0541}
N 1933 21770 1913 21770 {lab=VDD}
C {./lab_pin.sym} 1913 21770 0 0 {name=l1157_2 lab=VDD}
N 2117 21730 2137 21730 {lab=VDD}
C {./lab_pin.sym} 2137 21730 0 1 {name=l1157_3 lab=VDD}
N 2117 21750 2137 21750 {lab=VSS}
C {./lab_pin.sym} 2137 21750 0 1 {name=l1157_4 lab=VSS}
N 2117 21770 2137 21770 {lab=VSS}
C {./lab_pin.sym} 2137 21770 0 1 {name=l1157_5 lab=VSS}
C {./clkinv_1.sym} 2430 21750 0 0 {name=Xn_1099}
N 2338 21730 2318 21730 {lab=u_cas_diff_u_diff2_in_min1_b9}
C {./lab_pin.sym} 2318 21730 0 0 {name=l1158_0 lab=u_cas_diff_u_diff2_in_min1_b9}
N 2338 21750 2318 21750 {lab=n_0542}
C {./lab_pin.sym} 2318 21750 0 0 {name=l1158_1 lab=n_0542}
N 2338 21770 2318 21770 {lab=VDD}
C {./lab_pin.sym} 2318 21770 0 0 {name=l1158_2 lab=VDD}
N 2522 21730 2542 21730 {lab=VDD}
C {./lab_pin.sym} 2542 21730 0 1 {name=l1158_3 lab=VDD}
N 2522 21750 2542 21750 {lab=VSS}
C {./lab_pin.sym} 2542 21750 0 1 {name=l1158_4 lab=VSS}
N 2522 21770 2542 21770 {lab=VSS}
C {./lab_pin.sym} 2542 21770 0 1 {name=l1158_5 lab=VSS}
C {./clkinv_1.sym} 2835 21750 0 0 {name=Xn_1100}
N 2743 21730 2723 21730 {lab=u_cas_diff_out_diff1_b9}
C {./lab_pin.sym} 2723 21730 0 0 {name=l1159_0 lab=u_cas_diff_out_diff1_b9}
N 2743 21750 2723 21750 {lab=n_0543}
C {./lab_pin.sym} 2723 21750 0 0 {name=l1159_1 lab=n_0543}
N 2743 21770 2723 21770 {lab=VDD}
C {./lab_pin.sym} 2723 21770 0 0 {name=l1159_2 lab=VDD}
N 2927 21730 2947 21730 {lab=VDD}
C {./lab_pin.sym} 2947 21730 0 1 {name=l1159_3 lab=VDD}
N 2927 21750 2947 21750 {lab=VSS}
C {./lab_pin.sym} 2947 21750 0 1 {name=l1159_4 lab=VSS}
N 2927 21770 2947 21770 {lab=VSS}
C {./lab_pin.sym} 2947 21770 0 1 {name=l1159_5 lab=VSS}
C {./clkinv_1.sym} 3240 21750 0 0 {name=Xn_1101}
N 3148 21730 3128 21730 {lab=u_cas_diff_u_diff2_in_min1_b10}
C {./lab_pin.sym} 3128 21730 0 0 {name=l1160_0 lab=u_cas_diff_u_diff2_in_min1_b10}
N 3148 21750 3128 21750 {lab=n_0544}
C {./lab_pin.sym} 3128 21750 0 0 {name=l1160_1 lab=n_0544}
N 3148 21770 3128 21770 {lab=VDD}
C {./lab_pin.sym} 3128 21770 0 0 {name=l1160_2 lab=VDD}
N 3332 21730 3352 21730 {lab=VDD}
C {./lab_pin.sym} 3352 21730 0 1 {name=l1160_3 lab=VDD}
N 3332 21750 3352 21750 {lab=VSS}
C {./lab_pin.sym} 3352 21750 0 1 {name=l1160_4 lab=VSS}
N 3332 21770 3352 21770 {lab=VSS}
C {./lab_pin.sym} 3352 21770 0 1 {name=l1160_5 lab=VSS}
C {./clkinv_1.sym} 3645 21750 0 0 {name=Xn_1102}
N 3553 21730 3533 21730 {lab=u_cas_diff_out_diff1_b10}
C {./lab_pin.sym} 3533 21730 0 0 {name=l1161_0 lab=u_cas_diff_out_diff1_b10}
N 3553 21750 3533 21750 {lab=n_0545}
C {./lab_pin.sym} 3533 21750 0 0 {name=l1161_1 lab=n_0545}
N 3553 21770 3533 21770 {lab=VDD}
C {./lab_pin.sym} 3533 21770 0 0 {name=l1161_2 lab=VDD}
N 3737 21730 3757 21730 {lab=VDD}
C {./lab_pin.sym} 3757 21730 0 1 {name=l1161_3 lab=VDD}
N 3737 21750 3757 21750 {lab=VSS}
C {./lab_pin.sym} 3757 21750 0 1 {name=l1161_4 lab=VSS}
N 3737 21770 3757 21770 {lab=VSS}
C {./lab_pin.sym} 3757 21770 0 1 {name=l1161_5 lab=VSS}
C {./clkinv_1.sym} 4050 21750 0 0 {name=Xn_1103}
N 3958 21730 3938 21730 {lab=u_cas_diff_u_diff2_in_min1_b11}
C {./lab_pin.sym} 3938 21730 0 0 {name=l1162_0 lab=u_cas_diff_u_diff2_in_min1_b11}
N 3958 21750 3938 21750 {lab=n_0546}
C {./lab_pin.sym} 3938 21750 0 0 {name=l1162_1 lab=n_0546}
N 3958 21770 3938 21770 {lab=VDD}
C {./lab_pin.sym} 3938 21770 0 0 {name=l1162_2 lab=VDD}
N 4142 21730 4162 21730 {lab=VDD}
C {./lab_pin.sym} 4162 21730 0 1 {name=l1162_3 lab=VDD}
N 4142 21750 4162 21750 {lab=VSS}
C {./lab_pin.sym} 4162 21750 0 1 {name=l1162_4 lab=VSS}
N 4142 21770 4162 21770 {lab=VSS}
C {./lab_pin.sym} 4162 21770 0 1 {name=l1162_5 lab=VSS}
C {./clkinv_1.sym} 4455 21750 0 0 {name=Xn_1104}
N 4363 21730 4343 21730 {lab=u_cas_diff_out_diff1_b11}
C {./lab_pin.sym} 4343 21730 0 0 {name=l1163_0 lab=u_cas_diff_out_diff1_b11}
N 4363 21750 4343 21750 {lab=n_0547}
C {./lab_pin.sym} 4343 21750 0 0 {name=l1163_1 lab=n_0547}
N 4363 21770 4343 21770 {lab=VDD}
C {./lab_pin.sym} 4343 21770 0 0 {name=l1163_2 lab=VDD}
N 4547 21730 4567 21730 {lab=VDD}
C {./lab_pin.sym} 4567 21730 0 1 {name=l1163_3 lab=VDD}
N 4547 21750 4567 21750 {lab=VSS}
C {./lab_pin.sym} 4567 21750 0 1 {name=l1163_4 lab=VSS}
N 4547 21770 4567 21770 {lab=VSS}
C {./lab_pin.sym} 4567 21770 0 1 {name=l1163_5 lab=VSS}
C {./clkinv_1.sym} 0 21975 0 0 {name=Xn_1105}
N -92 21955 -112 21955 {lab=u_cas_diff_u_diff2_in_min1_b12}
C {./lab_pin.sym} -112 21955 0 0 {name=l1164_0 lab=u_cas_diff_u_diff2_in_min1_b12}
N -92 21975 -112 21975 {lab=n_0548}
C {./lab_pin.sym} -112 21975 0 0 {name=l1164_1 lab=n_0548}
N -92 21995 -112 21995 {lab=VDD}
C {./lab_pin.sym} -112 21995 0 0 {name=l1164_2 lab=VDD}
N 92 21955 112 21955 {lab=VDD}
C {./lab_pin.sym} 112 21955 0 1 {name=l1164_3 lab=VDD}
N 92 21975 112 21975 {lab=VSS}
C {./lab_pin.sym} 112 21975 0 1 {name=l1164_4 lab=VSS}
N 92 21995 112 21995 {lab=VSS}
C {./lab_pin.sym} 112 21995 0 1 {name=l1164_5 lab=VSS}
C {./clkinv_1.sym} 405 21975 0 0 {name=Xn_1106}
N 313 21955 293 21955 {lab=u_cas_diff_out_diff1_b12}
C {./lab_pin.sym} 293 21955 0 0 {name=l1165_0 lab=u_cas_diff_out_diff1_b12}
N 313 21975 293 21975 {lab=n_0549}
C {./lab_pin.sym} 293 21975 0 0 {name=l1165_1 lab=n_0549}
N 313 21995 293 21995 {lab=VDD}
C {./lab_pin.sym} 293 21995 0 0 {name=l1165_2 lab=VDD}
N 497 21955 517 21955 {lab=VDD}
C {./lab_pin.sym} 517 21955 0 1 {name=l1165_3 lab=VDD}
N 497 21975 517 21975 {lab=VSS}
C {./lab_pin.sym} 517 21975 0 1 {name=l1165_4 lab=VSS}
N 497 21995 517 21995 {lab=VSS}
C {./lab_pin.sym} 517 21995 0 1 {name=l1165_5 lab=VSS}
C {./clkinv_1.sym} 810 21975 0 0 {name=Xn_1107}
N 718 21955 698 21955 {lab=u_cas_diff_u_diff2_in_min1_b13}
C {./lab_pin.sym} 698 21955 0 0 {name=l1166_0 lab=u_cas_diff_u_diff2_in_min1_b13}
N 718 21975 698 21975 {lab=n_0550}
C {./lab_pin.sym} 698 21975 0 0 {name=l1166_1 lab=n_0550}
N 718 21995 698 21995 {lab=VDD}
C {./lab_pin.sym} 698 21995 0 0 {name=l1166_2 lab=VDD}
N 902 21955 922 21955 {lab=VDD}
C {./lab_pin.sym} 922 21955 0 1 {name=l1166_3 lab=VDD}
N 902 21975 922 21975 {lab=VSS}
C {./lab_pin.sym} 922 21975 0 1 {name=l1166_4 lab=VSS}
N 902 21995 922 21995 {lab=VSS}
C {./lab_pin.sym} 922 21995 0 1 {name=l1166_5 lab=VSS}
C {./clkinv_1.sym} 1215 21975 0 0 {name=Xn_1108}
N 1123 21955 1103 21955 {lab=u_cas_diff_out_diff1_b13}
C {./lab_pin.sym} 1103 21955 0 0 {name=l1167_0 lab=u_cas_diff_out_diff1_b13}
N 1123 21975 1103 21975 {lab=n_0551}
C {./lab_pin.sym} 1103 21975 0 0 {name=l1167_1 lab=n_0551}
N 1123 21995 1103 21995 {lab=VDD}
C {./lab_pin.sym} 1103 21995 0 0 {name=l1167_2 lab=VDD}
N 1307 21955 1327 21955 {lab=VDD}
C {./lab_pin.sym} 1327 21955 0 1 {name=l1167_3 lab=VDD}
N 1307 21975 1327 21975 {lab=VSS}
C {./lab_pin.sym} 1327 21975 0 1 {name=l1167_4 lab=VSS}
N 1307 21995 1327 21995 {lab=VSS}
C {./lab_pin.sym} 1327 21995 0 1 {name=l1167_5 lab=VSS}
C {./clkinv_1.sym} 1620 21975 0 0 {name=Xn_1109}
N 1528 21955 1508 21955 {lab=u_cas_diff_u_diff2_in_min1_b14}
C {./lab_pin.sym} 1508 21955 0 0 {name=l1168_0 lab=u_cas_diff_u_diff2_in_min1_b14}
N 1528 21975 1508 21975 {lab=n_0552}
C {./lab_pin.sym} 1508 21975 0 0 {name=l1168_1 lab=n_0552}
N 1528 21995 1508 21995 {lab=VDD}
C {./lab_pin.sym} 1508 21995 0 0 {name=l1168_2 lab=VDD}
N 1712 21955 1732 21955 {lab=VDD}
C {./lab_pin.sym} 1732 21955 0 1 {name=l1168_3 lab=VDD}
N 1712 21975 1732 21975 {lab=VSS}
C {./lab_pin.sym} 1732 21975 0 1 {name=l1168_4 lab=VSS}
N 1712 21995 1732 21995 {lab=VSS}
C {./lab_pin.sym} 1732 21995 0 1 {name=l1168_5 lab=VSS}
C {./clkinv_1.sym} 2025 21975 0 0 {name=Xn_1110}
N 1933 21955 1913 21955 {lab=u_cas_diff_out_diff1_b14}
C {./lab_pin.sym} 1913 21955 0 0 {name=l1169_0 lab=u_cas_diff_out_diff1_b14}
N 1933 21975 1913 21975 {lab=n_0553}
C {./lab_pin.sym} 1913 21975 0 0 {name=l1169_1 lab=n_0553}
N 1933 21995 1913 21995 {lab=VDD}
C {./lab_pin.sym} 1913 21995 0 0 {name=l1169_2 lab=VDD}
N 2117 21955 2137 21955 {lab=VDD}
C {./lab_pin.sym} 2137 21955 0 1 {name=l1169_3 lab=VDD}
N 2117 21975 2137 21975 {lab=VSS}
C {./lab_pin.sym} 2137 21975 0 1 {name=l1169_4 lab=VSS}
N 2117 21995 2137 21995 {lab=VSS}
C {./lab_pin.sym} 2137 21995 0 1 {name=l1169_5 lab=VSS}
C {./clkinv_1.sym} 2430 21975 0 0 {name=Xn_1111}
N 2338 21955 2318 21955 {lab=u_cas_diff_u_diff2_in_min1_b15}
C {./lab_pin.sym} 2318 21955 0 0 {name=l1170_0 lab=u_cas_diff_u_diff2_in_min1_b15}
N 2338 21975 2318 21975 {lab=n_0554}
C {./lab_pin.sym} 2318 21975 0 0 {name=l1170_1 lab=n_0554}
N 2338 21995 2318 21995 {lab=VDD}
C {./lab_pin.sym} 2318 21995 0 0 {name=l1170_2 lab=VDD}
N 2522 21955 2542 21955 {lab=VDD}
C {./lab_pin.sym} 2542 21955 0 1 {name=l1170_3 lab=VDD}
N 2522 21975 2542 21975 {lab=VSS}
C {./lab_pin.sym} 2542 21975 0 1 {name=l1170_4 lab=VSS}
N 2522 21995 2542 21995 {lab=VSS}
C {./lab_pin.sym} 2542 21995 0 1 {name=l1170_5 lab=VSS}
C {./clkinv_1.sym} 2835 21975 0 0 {name=Xn_1112}
N 2743 21955 2723 21955 {lab=u_cas_diff_out_diff1_b15}
C {./lab_pin.sym} 2723 21955 0 0 {name=l1171_0 lab=u_cas_diff_out_diff1_b15}
N 2743 21975 2723 21975 {lab=n_0555}
C {./lab_pin.sym} 2723 21975 0 0 {name=l1171_1 lab=n_0555}
N 2743 21995 2723 21995 {lab=VDD}
C {./lab_pin.sym} 2723 21995 0 0 {name=l1171_2 lab=VDD}
N 2927 21955 2947 21955 {lab=VDD}
C {./lab_pin.sym} 2947 21955 0 1 {name=l1171_3 lab=VDD}
N 2927 21975 2947 21975 {lab=VSS}
C {./lab_pin.sym} 2947 21975 0 1 {name=l1171_4 lab=VSS}
N 2927 21995 2947 21995 {lab=VSS}
C {./lab_pin.sym} 2947 21995 0 1 {name=l1171_5 lab=VSS}
C {./clkinv_1.sym} 3240 21975 0 0 {name=Xn_1113}
N 3148 21955 3128 21955 {lab=u_cas_diff_out_diff1_b16}
C {./lab_pin.sym} 3128 21955 0 0 {name=l1172_0 lab=u_cas_diff_out_diff1_b16}
N 3148 21975 3128 21975 {lab=n_0556}
C {./lab_pin.sym} 3128 21975 0 0 {name=l1172_1 lab=n_0556}
N 3148 21995 3128 21995 {lab=VDD}
C {./lab_pin.sym} 3128 21995 0 0 {name=l1172_2 lab=VDD}
N 3332 21955 3352 21955 {lab=VDD}
C {./lab_pin.sym} 3352 21955 0 1 {name=l1172_3 lab=VDD}
N 3332 21975 3352 21975 {lab=VSS}
C {./lab_pin.sym} 3352 21975 0 1 {name=l1172_4 lab=VSS}
N 3332 21995 3352 21995 {lab=VSS}
C {./lab_pin.sym} 3352 21995 0 1 {name=l1172_5 lab=VSS}
C {./clkinv_1.sym} 3645 21975 0 0 {name=Xn_1114}
N 3553 21955 3533 21955 {lab=u_cas_diff_u_diff2_in_min1_b17}
C {./lab_pin.sym} 3533 21955 0 0 {name=l1173_0 lab=u_cas_diff_u_diff2_in_min1_b17}
N 3553 21975 3533 21975 {lab=n_0557}
C {./lab_pin.sym} 3533 21975 0 0 {name=l1173_1 lab=n_0557}
N 3553 21995 3533 21995 {lab=VDD}
C {./lab_pin.sym} 3533 21995 0 0 {name=l1173_2 lab=VDD}
N 3737 21955 3757 21955 {lab=VDD}
C {./lab_pin.sym} 3757 21955 0 1 {name=l1173_3 lab=VDD}
N 3737 21975 3757 21975 {lab=VSS}
C {./lab_pin.sym} 3757 21975 0 1 {name=l1173_4 lab=VSS}
N 3737 21995 3757 21995 {lab=VSS}
C {./lab_pin.sym} 3757 21995 0 1 {name=l1173_5 lab=VSS}
C {./clkinv_1.sym} 4050 21975 0 0 {name=Xn_1115}
N 3958 21955 3938 21955 {lab=u_cas_diff_out_diff1_b17}
C {./lab_pin.sym} 3938 21955 0 0 {name=l1174_0 lab=u_cas_diff_out_diff1_b17}
N 3958 21975 3938 21975 {lab=n_0558}
C {./lab_pin.sym} 3938 21975 0 0 {name=l1174_1 lab=n_0558}
N 3958 21995 3938 21995 {lab=VDD}
C {./lab_pin.sym} 3938 21995 0 0 {name=l1174_2 lab=VDD}
N 4142 21955 4162 21955 {lab=VDD}
C {./lab_pin.sym} 4162 21955 0 1 {name=l1174_3 lab=VDD}
N 4142 21975 4162 21975 {lab=VSS}
C {./lab_pin.sym} 4162 21975 0 1 {name=l1174_4 lab=VSS}
N 4142 21995 4162 21995 {lab=VSS}
C {./lab_pin.sym} 4162 21995 0 1 {name=l1174_5 lab=VSS}
C {./clkinv_1.sym} 4455 21975 0 0 {name=Xn_1116}
N 4363 21955 4343 21955 {lab=u_cas_diff_out_diff1_b18}
C {./lab_pin.sym} 4343 21955 0 0 {name=l1175_0 lab=u_cas_diff_out_diff1_b18}
N 4363 21975 4343 21975 {lab=n_0559}
C {./lab_pin.sym} 4343 21975 0 0 {name=l1175_1 lab=n_0559}
N 4363 21995 4343 21995 {lab=VDD}
C {./lab_pin.sym} 4343 21995 0 0 {name=l1175_2 lab=VDD}
N 4547 21955 4567 21955 {lab=VDD}
C {./lab_pin.sym} 4567 21955 0 1 {name=l1175_3 lab=VDD}
N 4547 21975 4567 21975 {lab=VSS}
C {./lab_pin.sym} 4567 21975 0 1 {name=l1175_4 lab=VSS}
N 4547 21995 4567 21995 {lab=VSS}
C {./lab_pin.sym} 4567 21995 0 1 {name=l1175_5 lab=VSS}
C {./clkinv_1.sym} 0 22200 0 0 {name=Xn_1117}
N -92 22180 -112 22180 {lab=u_cas_diff_out_diff1_b19}
C {./lab_pin.sym} -112 22180 0 0 {name=l1176_0 lab=u_cas_diff_out_diff1_b19}
N -92 22200 -112 22200 {lab=n_0560}
C {./lab_pin.sym} -112 22200 0 0 {name=l1176_1 lab=n_0560}
N -92 22220 -112 22220 {lab=VDD}
C {./lab_pin.sym} -112 22220 0 0 {name=l1176_2 lab=VDD}
N 92 22180 112 22180 {lab=VDD}
C {./lab_pin.sym} 112 22180 0 1 {name=l1176_3 lab=VDD}
N 92 22200 112 22200 {lab=VSS}
C {./lab_pin.sym} 112 22200 0 1 {name=l1176_4 lab=VSS}
N 92 22220 112 22220 {lab=VSS}
C {./lab_pin.sym} 112 22220 0 1 {name=l1176_5 lab=VSS}
C {./clkinv_1.sym} 405 22200 0 0 {name=Xn_1118}
N 313 22180 293 22180 {lab=u_cas_diff_out_diff1_b20}
C {./lab_pin.sym} 293 22180 0 0 {name=l1177_0 lab=u_cas_diff_out_diff1_b20}
N 313 22200 293 22200 {lab=n_0561}
C {./lab_pin.sym} 293 22200 0 0 {name=l1177_1 lab=n_0561}
N 313 22220 293 22220 {lab=VDD}
C {./lab_pin.sym} 293 22220 0 0 {name=l1177_2 lab=VDD}
N 497 22180 517 22180 {lab=VDD}
C {./lab_pin.sym} 517 22180 0 1 {name=l1177_3 lab=VDD}
N 497 22200 517 22200 {lab=VSS}
C {./lab_pin.sym} 517 22200 0 1 {name=l1177_4 lab=VSS}
N 497 22220 517 22220 {lab=VSS}
C {./lab_pin.sym} 517 22220 0 1 {name=l1177_5 lab=VSS}
C {./clkinv_1.sym} 810 22200 0 0 {name=Xn_1119}
N 718 22180 698 22180 {lab=u_cas_diff_u_diff2_in_min1_b21}
C {./lab_pin.sym} 698 22180 0 0 {name=l1178_0 lab=u_cas_diff_u_diff2_in_min1_b21}
N 718 22200 698 22200 {lab=n_0562}
C {./lab_pin.sym} 698 22200 0 0 {name=l1178_1 lab=n_0562}
N 718 22220 698 22220 {lab=VDD}
C {./lab_pin.sym} 698 22220 0 0 {name=l1178_2 lab=VDD}
N 902 22180 922 22180 {lab=VDD}
C {./lab_pin.sym} 922 22180 0 1 {name=l1178_3 lab=VDD}
N 902 22200 922 22200 {lab=VSS}
C {./lab_pin.sym} 922 22200 0 1 {name=l1178_4 lab=VSS}
N 902 22220 922 22220 {lab=VSS}
C {./lab_pin.sym} 922 22220 0 1 {name=l1178_5 lab=VSS}
C {./clkinv_1.sym} 1215 22200 0 0 {name=Xn_1120}
N 1123 22180 1103 22180 {lab=u_cas_diff_u_diff2_in_min1_b22}
C {./lab_pin.sym} 1103 22180 0 0 {name=l1179_0 lab=u_cas_diff_u_diff2_in_min1_b22}
N 1123 22200 1103 22200 {lab=n_0563}
C {./lab_pin.sym} 1103 22200 0 0 {name=l1179_1 lab=n_0563}
N 1123 22220 1103 22220 {lab=VDD}
C {./lab_pin.sym} 1103 22220 0 0 {name=l1179_2 lab=VDD}
N 1307 22180 1327 22180 {lab=VDD}
C {./lab_pin.sym} 1327 22180 0 1 {name=l1179_3 lab=VDD}
N 1307 22200 1327 22200 {lab=VSS}
C {./lab_pin.sym} 1327 22200 0 1 {name=l1179_4 lab=VSS}
N 1307 22220 1327 22220 {lab=VSS}
C {./lab_pin.sym} 1327 22220 0 1 {name=l1179_5 lab=VSS}
C {./clkinv_1.sym} 1620 22200 0 0 {name=Xn_1121}
N 1528 22180 1508 22180 {lab=u_cas_diff_out_diff1_b22}
C {./lab_pin.sym} 1508 22180 0 0 {name=l1180_0 lab=u_cas_diff_out_diff1_b22}
N 1528 22200 1508 22200 {lab=n_0564}
C {./lab_pin.sym} 1508 22200 0 0 {name=l1180_1 lab=n_0564}
N 1528 22220 1508 22220 {lab=VDD}
C {./lab_pin.sym} 1508 22220 0 0 {name=l1180_2 lab=VDD}
N 1712 22180 1732 22180 {lab=VDD}
C {./lab_pin.sym} 1732 22180 0 1 {name=l1180_3 lab=VDD}
N 1712 22200 1732 22200 {lab=VSS}
C {./lab_pin.sym} 1732 22200 0 1 {name=l1180_4 lab=VSS}
N 1712 22220 1732 22220 {lab=VSS}
C {./lab_pin.sym} 1732 22220 0 1 {name=l1180_5 lab=VSS}
C {./clkinv_1.sym} 2025 22200 0 0 {name=Xn_1122}
N 1933 22180 1913 22180 {lab=u_cas_diff_u_diff2_in_min1_b23}
C {./lab_pin.sym} 1913 22180 0 0 {name=l1181_0 lab=u_cas_diff_u_diff2_in_min1_b23}
N 1933 22200 1913 22200 {lab=n_0565}
C {./lab_pin.sym} 1913 22200 0 0 {name=l1181_1 lab=n_0565}
N 1933 22220 1913 22220 {lab=VDD}
C {./lab_pin.sym} 1913 22220 0 0 {name=l1181_2 lab=VDD}
N 2117 22180 2137 22180 {lab=VDD}
C {./lab_pin.sym} 2137 22180 0 1 {name=l1181_3 lab=VDD}
N 2117 22200 2137 22200 {lab=VSS}
C {./lab_pin.sym} 2137 22200 0 1 {name=l1181_4 lab=VSS}
N 2117 22220 2137 22220 {lab=VSS}
C {./lab_pin.sym} 2137 22220 0 1 {name=l1181_5 lab=VSS}
C {./clkinv_1.sym} 2430 22200 0 0 {name=Xn_1123}
N 2338 22180 2318 22180 {lab=u_cas_diff_out_diff1_b23}
C {./lab_pin.sym} 2318 22180 0 0 {name=l1182_0 lab=u_cas_diff_out_diff1_b23}
N 2338 22200 2318 22200 {lab=n_0566}
C {./lab_pin.sym} 2318 22200 0 0 {name=l1182_1 lab=n_0566}
N 2338 22220 2318 22220 {lab=VDD}
C {./lab_pin.sym} 2318 22220 0 0 {name=l1182_2 lab=VDD}
N 2522 22180 2542 22180 {lab=VDD}
C {./lab_pin.sym} 2542 22180 0 1 {name=l1182_3 lab=VDD}
N 2522 22200 2542 22200 {lab=VSS}
C {./lab_pin.sym} 2542 22200 0 1 {name=l1182_4 lab=VSS}
N 2522 22220 2542 22220 {lab=VSS}
C {./lab_pin.sym} 2542 22220 0 1 {name=l1182_5 lab=VSS}
C {./clkinv_1.sym} 2835 22200 0 0 {name=Xn_1124}
N 2743 22180 2723 22180 {lab=u_cas_diff_u_diff1_in_min1_b2}
C {./lab_pin.sym} 2723 22180 0 0 {name=l1183_0 lab=u_cas_diff_u_diff1_in_min1_b2}
N 2743 22200 2723 22200 {lab=n_0567}
C {./lab_pin.sym} 2723 22200 0 0 {name=l1183_1 lab=n_0567}
N 2743 22220 2723 22220 {lab=VDD}
C {./lab_pin.sym} 2723 22220 0 0 {name=l1183_2 lab=VDD}
N 2927 22180 2947 22180 {lab=VDD}
C {./lab_pin.sym} 2947 22180 0 1 {name=l1183_3 lab=VDD}
N 2927 22200 2947 22200 {lab=VSS}
C {./lab_pin.sym} 2947 22200 0 1 {name=l1183_4 lab=VSS}
N 2927 22220 2947 22220 {lab=VSS}
C {./lab_pin.sym} 2947 22220 0 1 {name=l1183_5 lab=VSS}
C {./clkinv_1.sym} 3240 22200 0 0 {name=Xn_1125}
N 3148 22180 3128 22180 {lab=u_cas_diff_u_diff1_in_min1_b3}
C {./lab_pin.sym} 3128 22180 0 0 {name=l1184_0 lab=u_cas_diff_u_diff1_in_min1_b3}
N 3148 22200 3128 22200 {lab=n_0568}
C {./lab_pin.sym} 3128 22200 0 0 {name=l1184_1 lab=n_0568}
N 3148 22220 3128 22220 {lab=VDD}
C {./lab_pin.sym} 3128 22220 0 0 {name=l1184_2 lab=VDD}
N 3332 22180 3352 22180 {lab=VDD}
C {./lab_pin.sym} 3352 22180 0 1 {name=l1184_3 lab=VDD}
N 3332 22200 3352 22200 {lab=VSS}
C {./lab_pin.sym} 3352 22200 0 1 {name=l1184_4 lab=VSS}
N 3332 22220 3352 22220 {lab=VSS}
C {./lab_pin.sym} 3352 22220 0 1 {name=l1184_5 lab=VSS}
C {./clkinv_1.sym} 3645 22200 0 0 {name=Xn_1126}
N 3553 22180 3533 22180 {lab=u_cas_diff_u_diff1_in_min1_b4}
C {./lab_pin.sym} 3533 22180 0 0 {name=l1185_0 lab=u_cas_diff_u_diff1_in_min1_b4}
N 3553 22200 3533 22200 {lab=n_0569}
C {./lab_pin.sym} 3533 22200 0 0 {name=l1185_1 lab=n_0569}
N 3553 22220 3533 22220 {lab=VDD}
C {./lab_pin.sym} 3533 22220 0 0 {name=l1185_2 lab=VDD}
N 3737 22180 3757 22180 {lab=VDD}
C {./lab_pin.sym} 3757 22180 0 1 {name=l1185_3 lab=VDD}
N 3737 22200 3757 22200 {lab=VSS}
C {./lab_pin.sym} 3757 22200 0 1 {name=l1185_4 lab=VSS}
N 3737 22220 3757 22220 {lab=VSS}
C {./lab_pin.sym} 3757 22220 0 1 {name=l1185_5 lab=VSS}
C {./clkinv_1.sym} 4050 22200 0 0 {name=Xn_1127}
N 3958 22180 3938 22180 {lab=u_cas_diff_u_diff1_in_min1_b5}
C {./lab_pin.sym} 3938 22180 0 0 {name=l1186_0 lab=u_cas_diff_u_diff1_in_min1_b5}
N 3958 22200 3938 22200 {lab=n_0570}
C {./lab_pin.sym} 3938 22200 0 0 {name=l1186_1 lab=n_0570}
N 3958 22220 3938 22220 {lab=VDD}
C {./lab_pin.sym} 3938 22220 0 0 {name=l1186_2 lab=VDD}
N 4142 22180 4162 22180 {lab=VDD}
C {./lab_pin.sym} 4162 22180 0 1 {name=l1186_3 lab=VDD}
N 4142 22200 4162 22200 {lab=VSS}
C {./lab_pin.sym} 4162 22200 0 1 {name=l1186_4 lab=VSS}
N 4142 22220 4162 22220 {lab=VSS}
C {./lab_pin.sym} 4162 22220 0 1 {name=l1186_5 lab=VSS}
C {./clkinv_1.sym} 4455 22200 0 0 {name=Xn_1128}
N 4363 22180 4343 22180 {lab=u_cas_diff_u_diff1_in_min1_b6}
C {./lab_pin.sym} 4343 22180 0 0 {name=l1187_0 lab=u_cas_diff_u_diff1_in_min1_b6}
N 4363 22200 4343 22200 {lab=n_0571}
C {./lab_pin.sym} 4343 22200 0 0 {name=l1187_1 lab=n_0571}
N 4363 22220 4343 22220 {lab=VDD}
C {./lab_pin.sym} 4343 22220 0 0 {name=l1187_2 lab=VDD}
N 4547 22180 4567 22180 {lab=VDD}
C {./lab_pin.sym} 4567 22180 0 1 {name=l1187_3 lab=VDD}
N 4547 22200 4567 22200 {lab=VSS}
C {./lab_pin.sym} 4567 22200 0 1 {name=l1187_4 lab=VSS}
N 4547 22220 4567 22220 {lab=VSS}
C {./lab_pin.sym} 4567 22220 0 1 {name=l1187_5 lab=VSS}
C {./clkinv_1.sym} 0 22425 0 0 {name=Xn_1129}
N -92 22405 -112 22405 {lab=u_cas_diff_u_diff1_in_min1_b7}
C {./lab_pin.sym} -112 22405 0 0 {name=l1188_0 lab=u_cas_diff_u_diff1_in_min1_b7}
N -92 22425 -112 22425 {lab=n_0572}
C {./lab_pin.sym} -112 22425 0 0 {name=l1188_1 lab=n_0572}
N -92 22445 -112 22445 {lab=VDD}
C {./lab_pin.sym} -112 22445 0 0 {name=l1188_2 lab=VDD}
N 92 22405 112 22405 {lab=VDD}
C {./lab_pin.sym} 112 22405 0 1 {name=l1188_3 lab=VDD}
N 92 22425 112 22425 {lab=VSS}
C {./lab_pin.sym} 112 22425 0 1 {name=l1188_4 lab=VSS}
N 92 22445 112 22445 {lab=VSS}
C {./lab_pin.sym} 112 22445 0 1 {name=l1188_5 lab=VSS}
C {./clkinv_1.sym} 405 22425 0 0 {name=Xn_1130}
N 313 22405 293 22405 {lab=u_cas_diff_u_diff1_in_min1_b10}
C {./lab_pin.sym} 293 22405 0 0 {name=l1189_0 lab=u_cas_diff_u_diff1_in_min1_b10}
N 313 22425 293 22425 {lab=n_0573}
C {./lab_pin.sym} 293 22425 0 0 {name=l1189_1 lab=n_0573}
N 313 22445 293 22445 {lab=VDD}
C {./lab_pin.sym} 293 22445 0 0 {name=l1189_2 lab=VDD}
N 497 22405 517 22405 {lab=VDD}
C {./lab_pin.sym} 517 22405 0 1 {name=l1189_3 lab=VDD}
N 497 22425 517 22425 {lab=VSS}
C {./lab_pin.sym} 517 22425 0 1 {name=l1189_4 lab=VSS}
N 497 22445 517 22445 {lab=VSS}
C {./lab_pin.sym} 517 22445 0 1 {name=l1189_5 lab=VSS}
C {./clkinv_1.sym} 810 22425 0 0 {name=Xn_1131}
N 718 22405 698 22405 {lab=u_cas_diff_u_diff1_in_min1_b11}
C {./lab_pin.sym} 698 22405 0 0 {name=l1190_0 lab=u_cas_diff_u_diff1_in_min1_b11}
N 718 22425 698 22425 {lab=n_0574}
C {./lab_pin.sym} 698 22425 0 0 {name=l1190_1 lab=n_0574}
N 718 22445 698 22445 {lab=VDD}
C {./lab_pin.sym} 698 22445 0 0 {name=l1190_2 lab=VDD}
N 902 22405 922 22405 {lab=VDD}
C {./lab_pin.sym} 922 22405 0 1 {name=l1190_3 lab=VDD}
N 902 22425 922 22425 {lab=VSS}
C {./lab_pin.sym} 922 22425 0 1 {name=l1190_4 lab=VSS}
N 902 22445 922 22445 {lab=VSS}
C {./lab_pin.sym} 922 22445 0 1 {name=l1190_5 lab=VSS}
C {./clkinv_1.sym} 1215 22425 0 0 {name=Xn_1132}
N 1123 22405 1103 22405 {lab=u_cas_diff_u_diff1_in_min1_b12}
C {./lab_pin.sym} 1103 22405 0 0 {name=l1191_0 lab=u_cas_diff_u_diff1_in_min1_b12}
N 1123 22425 1103 22425 {lab=n_0575}
C {./lab_pin.sym} 1103 22425 0 0 {name=l1191_1 lab=n_0575}
N 1123 22445 1103 22445 {lab=VDD}
C {./lab_pin.sym} 1103 22445 0 0 {name=l1191_2 lab=VDD}
N 1307 22405 1327 22405 {lab=VDD}
C {./lab_pin.sym} 1327 22405 0 1 {name=l1191_3 lab=VDD}
N 1307 22425 1327 22425 {lab=VSS}
C {./lab_pin.sym} 1327 22425 0 1 {name=l1191_4 lab=VSS}
N 1307 22445 1327 22445 {lab=VSS}
C {./lab_pin.sym} 1327 22445 0 1 {name=l1191_5 lab=VSS}
C {./clkinv_1.sym} 1620 22425 0 0 {name=Xn_1133}
N 1528 22405 1508 22405 {lab=u_cas_diff_u_diff1_in_min1_b13}
C {./lab_pin.sym} 1508 22405 0 0 {name=l1192_0 lab=u_cas_diff_u_diff1_in_min1_b13}
N 1528 22425 1508 22425 {lab=n_0576}
C {./lab_pin.sym} 1508 22425 0 0 {name=l1192_1 lab=n_0576}
N 1528 22445 1508 22445 {lab=VDD}
C {./lab_pin.sym} 1508 22445 0 0 {name=l1192_2 lab=VDD}
N 1712 22405 1732 22405 {lab=VDD}
C {./lab_pin.sym} 1732 22405 0 1 {name=l1192_3 lab=VDD}
N 1712 22425 1732 22425 {lab=VSS}
C {./lab_pin.sym} 1732 22425 0 1 {name=l1192_4 lab=VSS}
N 1712 22445 1732 22445 {lab=VSS}
C {./lab_pin.sym} 1732 22445 0 1 {name=l1192_5 lab=VSS}
C {./clkinv_1.sym} 2025 22425 0 0 {name=Xn_1134}
N 1933 22405 1913 22405 {lab=u_cas_diff_u_diff1_in_min1_b14}
C {./lab_pin.sym} 1913 22405 0 0 {name=l1193_0 lab=u_cas_diff_u_diff1_in_min1_b14}
N 1933 22425 1913 22425 {lab=n_0577}
C {./lab_pin.sym} 1913 22425 0 0 {name=l1193_1 lab=n_0577}
N 1933 22445 1913 22445 {lab=VDD}
C {./lab_pin.sym} 1913 22445 0 0 {name=l1193_2 lab=VDD}
N 2117 22405 2137 22405 {lab=VDD}
C {./lab_pin.sym} 2137 22405 0 1 {name=l1193_3 lab=VDD}
N 2117 22425 2137 22425 {lab=VSS}
C {./lab_pin.sym} 2137 22425 0 1 {name=l1193_4 lab=VSS}
N 2117 22445 2137 22445 {lab=VSS}
C {./lab_pin.sym} 2137 22445 0 1 {name=l1193_5 lab=VSS}
C {./clkinv_1.sym} 2430 22425 0 0 {name=Xn_1135}
N 2338 22405 2318 22405 {lab=u_cas_diff_u_diff1_in_min1_b15}
C {./lab_pin.sym} 2318 22405 0 0 {name=l1194_0 lab=u_cas_diff_u_diff1_in_min1_b15}
N 2338 22425 2318 22425 {lab=n_0578}
C {./lab_pin.sym} 2318 22425 0 0 {name=l1194_1 lab=n_0578}
N 2338 22445 2318 22445 {lab=VDD}
C {./lab_pin.sym} 2318 22445 0 0 {name=l1194_2 lab=VDD}
N 2522 22405 2542 22405 {lab=VDD}
C {./lab_pin.sym} 2542 22405 0 1 {name=l1194_3 lab=VDD}
N 2522 22425 2542 22425 {lab=VSS}
C {./lab_pin.sym} 2542 22425 0 1 {name=l1194_4 lab=VSS}
N 2522 22445 2542 22445 {lab=VSS}
C {./lab_pin.sym} 2542 22445 0 1 {name=l1194_5 lab=VSS}
C {./clkinv_1.sym} 2835 22425 0 0 {name=Xn_1136}
N 2743 22405 2723 22405 {lab=u_cas_diff_u_diff1_in_min1_b17}
C {./lab_pin.sym} 2723 22405 0 0 {name=l1195_0 lab=u_cas_diff_u_diff1_in_min1_b17}
N 2743 22425 2723 22425 {lab=n_0579}
C {./lab_pin.sym} 2723 22425 0 0 {name=l1195_1 lab=n_0579}
N 2743 22445 2723 22445 {lab=VDD}
C {./lab_pin.sym} 2723 22445 0 0 {name=l1195_2 lab=VDD}
N 2927 22405 2947 22405 {lab=VDD}
C {./lab_pin.sym} 2947 22405 0 1 {name=l1195_3 lab=VDD}
N 2927 22425 2947 22425 {lab=VSS}
C {./lab_pin.sym} 2947 22425 0 1 {name=l1195_4 lab=VSS}
N 2927 22445 2947 22445 {lab=VSS}
C {./lab_pin.sym} 2947 22445 0 1 {name=l1195_5 lab=VSS}
C {./clkinv_1.sym} 3240 22425 0 0 {name=Xn_1137}
N 3148 22405 3128 22405 {lab=u_cas_diff_u_diff1_in_min1_b18}
C {./lab_pin.sym} 3128 22405 0 0 {name=l1196_0 lab=u_cas_diff_u_diff1_in_min1_b18}
N 3148 22425 3128 22425 {lab=n_0580}
C {./lab_pin.sym} 3128 22425 0 0 {name=l1196_1 lab=n_0580}
N 3148 22445 3128 22445 {lab=VDD}
C {./lab_pin.sym} 3128 22445 0 0 {name=l1196_2 lab=VDD}
N 3332 22405 3352 22405 {lab=VDD}
C {./lab_pin.sym} 3352 22405 0 1 {name=l1196_3 lab=VDD}
N 3332 22425 3352 22425 {lab=VSS}
C {./lab_pin.sym} 3352 22425 0 1 {name=l1196_4 lab=VSS}
N 3332 22445 3352 22445 {lab=VSS}
C {./lab_pin.sym} 3352 22445 0 1 {name=l1196_5 lab=VSS}
C {./clkinv_1.sym} 3645 22425 0 0 {name=Xn_1138}
N 3553 22405 3533 22405 {lab=u_cas_diff_u_diff1_in_min1_b19}
C {./lab_pin.sym} 3533 22405 0 0 {name=l1197_0 lab=u_cas_diff_u_diff1_in_min1_b19}
N 3553 22425 3533 22425 {lab=n_0581}
C {./lab_pin.sym} 3533 22425 0 0 {name=l1197_1 lab=n_0581}
N 3553 22445 3533 22445 {lab=VDD}
C {./lab_pin.sym} 3533 22445 0 0 {name=l1197_2 lab=VDD}
N 3737 22405 3757 22405 {lab=VDD}
C {./lab_pin.sym} 3757 22405 0 1 {name=l1197_3 lab=VDD}
N 3737 22425 3757 22425 {lab=VSS}
C {./lab_pin.sym} 3757 22425 0 1 {name=l1197_4 lab=VSS}
N 3737 22445 3757 22445 {lab=VSS}
C {./lab_pin.sym} 3757 22445 0 1 {name=l1197_5 lab=VSS}
C {./clkinv_1.sym} 4050 22425 0 0 {name=Xn_1139}
N 3958 22405 3938 22405 {lab=u_cas_diff_u_diff1_in_min1_b20}
C {./lab_pin.sym} 3938 22405 0 0 {name=l1198_0 lab=u_cas_diff_u_diff1_in_min1_b20}
N 3958 22425 3938 22425 {lab=n_0582}
C {./lab_pin.sym} 3938 22425 0 0 {name=l1198_1 lab=n_0582}
N 3958 22445 3938 22445 {lab=VDD}
C {./lab_pin.sym} 3938 22445 0 0 {name=l1198_2 lab=VDD}
N 4142 22405 4162 22405 {lab=VDD}
C {./lab_pin.sym} 4162 22405 0 1 {name=l1198_3 lab=VDD}
N 4142 22425 4162 22425 {lab=VSS}
C {./lab_pin.sym} 4162 22425 0 1 {name=l1198_4 lab=VSS}
N 4142 22445 4162 22445 {lab=VSS}
C {./lab_pin.sym} 4162 22445 0 1 {name=l1198_5 lab=VSS}
C {./clkinv_1.sym} 4455 22425 0 0 {name=Xn_1140}
N 4363 22405 4343 22405 {lab=u_cas_diff_u_diff1_in_min1_b21}
C {./lab_pin.sym} 4343 22405 0 0 {name=l1199_0 lab=u_cas_diff_u_diff1_in_min1_b21}
N 4363 22425 4343 22425 {lab=n_0583}
C {./lab_pin.sym} 4343 22425 0 0 {name=l1199_1 lab=n_0583}
N 4363 22445 4343 22445 {lab=VDD}
C {./lab_pin.sym} 4343 22445 0 0 {name=l1199_2 lab=VDD}
N 4547 22405 4567 22405 {lab=VDD}
C {./lab_pin.sym} 4567 22405 0 1 {name=l1199_3 lab=VDD}
N 4547 22425 4567 22425 {lab=VSS}
C {./lab_pin.sym} 4567 22425 0 1 {name=l1199_4 lab=VSS}
N 4547 22445 4567 22445 {lab=VSS}
C {./lab_pin.sym} 4567 22445 0 1 {name=l1199_5 lab=VSS}
C {./clkinv_1.sym} 0 22650 0 0 {name=Xn_1141}
N -92 22630 -112 22630 {lab=u_cas_diff_u_diff1_in_min1_b22}
C {./lab_pin.sym} -112 22630 0 0 {name=l1200_0 lab=u_cas_diff_u_diff1_in_min1_b22}
N -92 22650 -112 22650 {lab=n_0584}
C {./lab_pin.sym} -112 22650 0 0 {name=l1200_1 lab=n_0584}
N -92 22670 -112 22670 {lab=VDD}
C {./lab_pin.sym} -112 22670 0 0 {name=l1200_2 lab=VDD}
N 92 22630 112 22630 {lab=VDD}
C {./lab_pin.sym} 112 22630 0 1 {name=l1200_3 lab=VDD}
N 92 22650 112 22650 {lab=VSS}
C {./lab_pin.sym} 112 22650 0 1 {name=l1200_4 lab=VSS}
N 92 22670 112 22670 {lab=VSS}
C {./lab_pin.sym} 112 22670 0 1 {name=l1200_5 lab=VSS}
C {./clkinv_1.sym} 405 22650 0 0 {name=Xn_1142}
N 313 22630 293 22630 {lab=u_cas_diff_u_diff1_in_min1_b23}
C {./lab_pin.sym} 293 22630 0 0 {name=l1201_0 lab=u_cas_diff_u_diff1_in_min1_b23}
N 313 22650 293 22650 {lab=n_0585}
C {./lab_pin.sym} 293 22650 0 0 {name=l1201_1 lab=n_0585}
N 313 22670 293 22670 {lab=VDD}
C {./lab_pin.sym} 293 22670 0 0 {name=l1201_2 lab=VDD}
N 497 22630 517 22630 {lab=VDD}
C {./lab_pin.sym} 517 22630 0 1 {name=l1201_3 lab=VDD}
N 497 22650 517 22650 {lab=VSS}
C {./lab_pin.sym} 517 22650 0 1 {name=l1201_4 lab=VSS}
N 497 22670 517 22670 {lab=VSS}
C {./lab_pin.sym} 517 22670 0 1 {name=l1201_5 lab=VSS}
C {./clkinv_1.sym} 810 22650 0 0 {name=Xn_1143}
N 718 22630 698 22630 {lab=u_clock_div_counter_b0}
C {./lab_pin.sym} 698 22630 0 0 {name=l1202_0 lab=u_clock_div_counter_b0}
N 718 22650 698 22650 {lab=n_0137}
C {./lab_pin.sym} 698 22650 0 0 {name=l1202_1 lab=n_0137}
N 718 22670 698 22670 {lab=VDD}
C {./lab_pin.sym} 698 22670 0 0 {name=l1202_2 lab=VDD}
N 902 22630 922 22630 {lab=VDD}
C {./lab_pin.sym} 922 22630 0 1 {name=l1202_3 lab=VDD}
N 902 22650 922 22650 {lab=VSS}
C {./lab_pin.sym} 922 22650 0 1 {name=l1202_4 lab=VSS}
N 902 22670 922 22670 {lab=VSS}
C {./lab_pin.sym} 922 22670 0 1 {name=l1202_5 lab=VSS}
C {./nand2_1.sym} 1215 22650 0 0 {name=Xn_1144}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__nand2_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -50 72 -50 {}
L 4 72 -50 72 50 {}
L 4 72 50 -72 50 {}
L 4 -72 50 -72 -50 {}
T {@name} -72 -70 0 0 0.33 0.33 {}
T {nand2_1} -68 39 0 0 0.2 0.2 {}
L 4 -92 -30 -72 -30 {}
T {A1} -66 -35 0 0 0.16 0.16 {}
L 4 -92 -10 -72 -10 {}
T {A2} -66 -15 0 0 0.16 0.16 {}
L 4 -92 10 -72 10 {}
T {ZN} -66 5 0 0 0.16 0.16 {}
L 4 -92 30 -72 30 {}
T {VDD} -66 25 0 0 0.16 0.16 {}
L 4 92 -20 72 -20 {}
T {VNW} 50.2 -25 0 0 0.16 0.16 {}
L 4 92 0 72 0 {}
T {VPW} 50.2 -5 0 0 0.16 0.16 {}
L 4 92 20 72 20 {}
T {VSS} 50.2 15 0 0 0.16 0.16 {}
B 5 -94 -32 -90 -28 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -12 -90 -8 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 8 -90 12 {name=ZN dir=inout sim_pinnumber=3}
B 5 -94 28 -90 32 {name=VDD dir=inout sim_pinnumber=4}
B 5 90 -22 94 -18 {name=VNW dir=inout sim_pinnumber=5}
B 5 90 -2 94 2 {name=VPW dir=inout sim_pinnumber=6}
B 5 90 18 94 22 {name=VSS dir=inout sim_pinnumber=7}
]
N 1123 22620 1103 22620 {lab=u_clock_div_counter_b0}
C {./lab_pin.sym} 1103 22620 0 0 {name=l1203_0 lab=u_clock_div_counter_b0}
N 1123 22640 1103 22640 {lab=u_clock_div_counter_b1}
C {./lab_pin.sym} 1103 22640 0 0 {name=l1203_1 lab=u_clock_div_counter_b1}
N 1123 22660 1103 22660 {lab=n_0586}
C {./lab_pin.sym} 1103 22660 0 0 {name=l1203_2 lab=n_0586}
N 1123 22680 1103 22680 {lab=VDD}
C {./lab_pin.sym} 1103 22680 0 0 {name=l1203_3 lab=VDD}
N 1307 22630 1327 22630 {lab=VDD}
C {./lab_pin.sym} 1327 22630 0 1 {name=l1203_4 lab=VDD}
N 1307 22650 1327 22650 {lab=VSS}
C {./lab_pin.sym} 1327 22650 0 1 {name=l1203_5 lab=VSS}
N 1307 22670 1327 22670 {lab=VSS}
C {./lab_pin.sym} 1327 22670 0 1 {name=l1203_6 lab=VSS}
C {./nand3_1.sym} 1620 22650 0 0 {name=Xn_1145}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__nand3_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -50 72 -50 {}
L 4 72 -50 72 50 {}
L 4 72 50 -72 50 {}
L 4 -72 50 -72 -50 {}
T {@name} -72 -70 0 0 0.33 0.33 {}
T {nand3_1} -68 39 0 0 0.2 0.2 {}
L 4 -92 -30 -72 -30 {}
T {A1} -66 -35 0 0 0.16 0.16 {}
L 4 -92 -10 -72 -10 {}
T {A2} -66 -15 0 0 0.16 0.16 {}
L 4 -92 10 -72 10 {}
T {A3} -66 5 0 0 0.16 0.16 {}
L 4 -92 30 -72 30 {}
T {ZN} -66 25 0 0 0.16 0.16 {}
L 4 92 -30 72 -30 {}
T {VDD} 50.2 -35 0 0 0.16 0.16 {}
L 4 92 -10 72 -10 {}
T {VNW} 50.2 -15 0 0 0.16 0.16 {}
L 4 92 10 72 10 {}
T {VPW} 50.2 5 0 0 0.16 0.16 {}
L 4 92 30 72 30 {}
T {VSS} 50.2 25 0 0 0.16 0.16 {}
B 5 -94 -32 -90 -28 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -12 -90 -8 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 8 -90 12 {name=A3 dir=inout sim_pinnumber=3}
B 5 -94 28 -90 32 {name=ZN dir=inout sim_pinnumber=4}
B 5 90 -32 94 -28 {name=VDD dir=inout sim_pinnumber=5}
B 5 90 -12 94 -8 {name=VNW dir=inout sim_pinnumber=6}
B 5 90 8 94 12 {name=VPW dir=inout sim_pinnumber=7}
B 5 90 28 94 32 {name=VSS dir=inout sim_pinnumber=8}
]
N 1528 22620 1508 22620 {lab=u_clock_div_counter_b2}
C {./lab_pin.sym} 1508 22620 0 0 {name=l1204_0 lab=u_clock_div_counter_b2}
N 1528 22640 1508 22640 {lab=u_clock_div_counter_b0}
C {./lab_pin.sym} 1508 22640 0 0 {name=l1204_1 lab=u_clock_div_counter_b0}
N 1528 22660 1508 22660 {lab=u_clock_div_counter_b1}
C {./lab_pin.sym} 1508 22660 0 0 {name=l1204_2 lab=u_clock_div_counter_b1}
N 1528 22680 1508 22680 {lab=n_0587}
C {./lab_pin.sym} 1508 22680 0 0 {name=l1204_3 lab=n_0587}
N 1712 22620 1732 22620 {lab=VDD}
C {./lab_pin.sym} 1732 22620 0 1 {name=l1204_4 lab=VDD}
N 1712 22640 1732 22640 {lab=VDD}
C {./lab_pin.sym} 1732 22640 0 1 {name=l1204_5 lab=VDD}
N 1712 22660 1732 22660 {lab=VSS}
C {./lab_pin.sym} 1732 22660 0 1 {name=l1204_6 lab=VSS}
N 1712 22680 1732 22680 {lab=VSS}
C {./lab_pin.sym} 1732 22680 0 1 {name=l1204_7 lab=VSS}
C {./and4_1.sym} 2025 22650 0 0 {name=Xn_1146}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__and4_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -60 72 -60 {}
L 4 72 -60 72 60 {}
L 4 72 60 -72 60 {}
L 4 -72 60 -72 -60 {}
T {@name} -72 -80 0 0 0.33 0.33 {}
T {and4_1} -68 49 0 0 0.2 0.2 {}
L 4 -92 -40 -72 -40 {}
T {A1} -66 -45 0 0 0.16 0.16 {}
L 4 -92 -20 -72 -20 {}
T {A2} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {A3} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {A4} -66 15 0 0 0.16 0.16 {}
L 4 -92 40 -72 40 {}
T {Z} -66 35 0 0 0.16 0.16 {}
L 4 92 -30 72 -30 {}
T {VDD} 50.2 -35 0 0 0.16 0.16 {}
L 4 92 -10 72 -10 {}
T {VNW} 50.2 -15 0 0 0.16 0.16 {}
L 4 92 10 72 10 {}
T {VPW} 50.2 5 0 0 0.16 0.16 {}
L 4 92 30 72 30 {}
T {VSS} 50.2 25 0 0 0.16 0.16 {}
B 5 -94 -42 -90 -38 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -22 -90 -18 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 -2 -90 2 {name=A3 dir=inout sim_pinnumber=3}
B 5 -94 18 -90 22 {name=A4 dir=inout sim_pinnumber=4}
B 5 -94 38 -90 42 {name=Z dir=inout sim_pinnumber=5}
B 5 90 -32 94 -28 {name=VDD dir=inout sim_pinnumber=6}
B 5 90 -12 94 -8 {name=VNW dir=inout sim_pinnumber=7}
B 5 90 8 94 12 {name=VPW dir=inout sim_pinnumber=8}
B 5 90 28 94 32 {name=VSS dir=inout sim_pinnumber=9}
]
N 1933 22610 1913 22610 {lab=u_clock_div_counter_b3}
C {./lab_pin.sym} 1913 22610 0 0 {name=l1205_0 lab=u_clock_div_counter_b3}
N 1933 22630 1913 22630 {lab=u_clock_div_counter_b2}
C {./lab_pin.sym} 1913 22630 0 0 {name=l1205_1 lab=u_clock_div_counter_b2}
N 1933 22650 1913 22650 {lab=u_clock_div_counter_b0}
C {./lab_pin.sym} 1913 22650 0 0 {name=l1205_2 lab=u_clock_div_counter_b0}
N 1933 22670 1913 22670 {lab=u_clock_div_counter_b1}
C {./lab_pin.sym} 1913 22670 0 0 {name=l1205_3 lab=u_clock_div_counter_b1}
N 1933 22690 1913 22690 {lab=n_0588}
C {./lab_pin.sym} 1913 22690 0 0 {name=l1205_4 lab=n_0588}
N 2117 22620 2137 22620 {lab=VDD}
C {./lab_pin.sym} 2137 22620 0 1 {name=l1205_5 lab=VDD}
N 2117 22640 2137 22640 {lab=VDD}
C {./lab_pin.sym} 2137 22640 0 1 {name=l1205_6 lab=VDD}
N 2117 22660 2137 22660 {lab=VSS}
C {./lab_pin.sym} 2137 22660 0 1 {name=l1205_7 lab=VSS}
N 2117 22680 2137 22680 {lab=VSS}
C {./lab_pin.sym} 2137 22680 0 1 {name=l1205_8 lab=VSS}
C {./nand2_1.sym} 2430 22650 0 0 {name=Xn_1147}
N 2338 22620 2318 22620 {lab=u_clock_div_counter_b4}
C {./lab_pin.sym} 2318 22620 0 0 {name=l1206_0 lab=u_clock_div_counter_b4}
N 2338 22640 2318 22640 {lab=n_0588}
C {./lab_pin.sym} 2318 22640 0 0 {name=l1206_1 lab=n_0588}
N 2338 22660 2318 22660 {lab=n_0589}
C {./lab_pin.sym} 2318 22660 0 0 {name=l1206_2 lab=n_0589}
N 2338 22680 2318 22680 {lab=VDD}
C {./lab_pin.sym} 2318 22680 0 0 {name=l1206_3 lab=VDD}
N 2522 22630 2542 22630 {lab=VDD}
C {./lab_pin.sym} 2542 22630 0 1 {name=l1206_4 lab=VDD}
N 2522 22650 2542 22650 {lab=VSS}
C {./lab_pin.sym} 2542 22650 0 1 {name=l1206_5 lab=VSS}
N 2522 22670 2542 22670 {lab=VSS}
C {./lab_pin.sym} 2542 22670 0 1 {name=l1206_6 lab=VSS}
C {./xor2_1.sym} 2835 22650 0 0 {name=Xn_1148}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__xor2_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -50 72 -50 {}
L 4 72 -50 72 50 {}
L 4 72 50 -72 50 {}
L 4 -72 50 -72 -50 {}
T {@name} -72 -70 0 0 0.33 0.33 {}
T {xor2_1} -68 39 0 0 0.2 0.2 {}
L 4 -92 -30 -72 -30 {}
T {A1} -66 -35 0 0 0.16 0.16 {}
L 4 -92 -10 -72 -10 {}
T {A2} -66 -15 0 0 0.16 0.16 {}
L 4 -92 10 -72 10 {}
T {Z} -66 5 0 0 0.16 0.16 {}
L 4 -92 30 -72 30 {}
T {VDD} -66 25 0 0 0.16 0.16 {}
L 4 92 -20 72 -20 {}
T {VNW} 50.2 -25 0 0 0.16 0.16 {}
L 4 92 0 72 0 {}
T {VPW} 50.2 -5 0 0 0.16 0.16 {}
L 4 92 20 72 20 {}
T {VSS} 50.2 15 0 0 0.16 0.16 {}
B 5 -94 -32 -90 -28 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -12 -90 -8 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 8 -90 12 {name=Z dir=inout sim_pinnumber=3}
B 5 -94 28 -90 32 {name=VDD dir=inout sim_pinnumber=4}
B 5 90 -22 94 -18 {name=VNW dir=inout sim_pinnumber=5}
B 5 90 -2 94 2 {name=VPW dir=inout sim_pinnumber=6}
B 5 90 18 94 22 {name=VSS dir=inout sim_pinnumber=7}
]
N 2743 22620 2723 22620 {lab=u_clock_div_counter_b4}
C {./lab_pin.sym} 2723 22620 0 0 {name=l1207_0 lab=u_clock_div_counter_b4}
N 2743 22640 2723 22640 {lab=n_0588}
C {./lab_pin.sym} 2723 22640 0 0 {name=l1207_1 lab=n_0588}
N 2743 22660 2723 22660 {lab=n_0141}
C {./lab_pin.sym} 2723 22660 0 0 {name=l1207_2 lab=n_0141}
N 2743 22680 2723 22680 {lab=VDD}
C {./lab_pin.sym} 2723 22680 0 0 {name=l1207_3 lab=VDD}
N 2927 22630 2947 22630 {lab=VDD}
C {./lab_pin.sym} 2947 22630 0 1 {name=l1207_4 lab=VDD}
N 2927 22650 2947 22650 {lab=VSS}
C {./lab_pin.sym} 2947 22650 0 1 {name=l1207_5 lab=VSS}
N 2927 22670 2947 22670 {lab=VSS}
C {./lab_pin.sym} 2947 22670 0 1 {name=l1207_6 lab=VSS}
C {./nand3_1.sym} 3240 22650 0 0 {name=Xn_1149}
N 3148 22620 3128 22620 {lab=u_clock_div_counter_b4}
C {./lab_pin.sym} 3128 22620 0 0 {name=l1208_0 lab=u_clock_div_counter_b4}
N 3148 22640 3128 22640 {lab=u_clock_div_counter_b5}
C {./lab_pin.sym} 3128 22640 0 0 {name=l1208_1 lab=u_clock_div_counter_b5}
N 3148 22660 3128 22660 {lab=n_0588}
C {./lab_pin.sym} 3128 22660 0 0 {name=l1208_2 lab=n_0588}
N 3148 22680 3128 22680 {lab=n_0590}
C {./lab_pin.sym} 3128 22680 0 0 {name=l1208_3 lab=n_0590}
N 3332 22620 3352 22620 {lab=VDD}
C {./lab_pin.sym} 3352 22620 0 1 {name=l1208_4 lab=VDD}
N 3332 22640 3352 22640 {lab=VDD}
C {./lab_pin.sym} 3352 22640 0 1 {name=l1208_5 lab=VDD}
N 3332 22660 3352 22660 {lab=VSS}
C {./lab_pin.sym} 3352 22660 0 1 {name=l1208_6 lab=VSS}
N 3332 22680 3352 22680 {lab=VSS}
C {./lab_pin.sym} 3352 22680 0 1 {name=l1208_7 lab=VSS}
C {./xnor2_1.sym} 3645 22650 0 0 {name=Xn_1150}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__xnor2_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -50 72 -50 {}
L 4 72 -50 72 50 {}
L 4 72 50 -72 50 {}
L 4 -72 50 -72 -50 {}
T {@name} -72 -70 0 0 0.33 0.33 {}
T {xnor2_1} -68 39 0 0 0.2 0.2 {}
L 4 -92 -30 -72 -30 {}
T {A1} -66 -35 0 0 0.16 0.16 {}
L 4 -92 -10 -72 -10 {}
T {A2} -66 -15 0 0 0.16 0.16 {}
L 4 -92 10 -72 10 {}
T {ZN} -66 5 0 0 0.16 0.16 {}
L 4 -92 30 -72 30 {}
T {VDD} -66 25 0 0 0.16 0.16 {}
L 4 92 -20 72 -20 {}
T {VNW} 50.2 -25 0 0 0.16 0.16 {}
L 4 92 0 72 0 {}
T {VPW} 50.2 -5 0 0 0.16 0.16 {}
L 4 92 20 72 20 {}
T {VSS} 50.2 15 0 0 0.16 0.16 {}
B 5 -94 -32 -90 -28 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -12 -90 -8 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 8 -90 12 {name=ZN dir=inout sim_pinnumber=3}
B 5 -94 28 -90 32 {name=VDD dir=inout sim_pinnumber=4}
B 5 90 -22 94 -18 {name=VNW dir=inout sim_pinnumber=5}
B 5 90 -2 94 2 {name=VPW dir=inout sim_pinnumber=6}
B 5 90 18 94 22 {name=VSS dir=inout sim_pinnumber=7}
]
N 3553 22620 3533 22620 {lab=u_clock_div_counter_b5}
C {./lab_pin.sym} 3533 22620 0 0 {name=l1209_0 lab=u_clock_div_counter_b5}
N 3553 22640 3533 22640 {lab=n_0589}
C {./lab_pin.sym} 3533 22640 0 0 {name=l1209_1 lab=n_0589}
N 3553 22660 3533 22660 {lab=n_0142}
C {./lab_pin.sym} 3533 22660 0 0 {name=l1209_2 lab=n_0142}
N 3553 22680 3533 22680 {lab=VDD}
C {./lab_pin.sym} 3533 22680 0 0 {name=l1209_3 lab=VDD}
N 3737 22630 3757 22630 {lab=VDD}
C {./lab_pin.sym} 3757 22630 0 1 {name=l1209_4 lab=VDD}
N 3737 22650 3757 22650 {lab=VSS}
C {./lab_pin.sym} 3757 22650 0 1 {name=l1209_5 lab=VSS}
N 3737 22670 3757 22670 {lab=VSS}
C {./lab_pin.sym} 3757 22670 0 1 {name=l1209_6 lab=VSS}
C {./nand4_1.sym} 4050 22650 0 0 {name=Xn_1151}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__nand4_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -60 72 -60 {}
L 4 72 -60 72 60 {}
L 4 72 60 -72 60 {}
L 4 -72 60 -72 -60 {}
T {@name} -72 -80 0 0 0.33 0.33 {}
T {nand4_1} -68 49 0 0 0.2 0.2 {}
L 4 -92 -40 -72 -40 {}
T {A1} -66 -45 0 0 0.16 0.16 {}
L 4 -92 -20 -72 -20 {}
T {A2} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {A3} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {A4} -66 15 0 0 0.16 0.16 {}
L 4 -92 40 -72 40 {}
T {ZN} -66 35 0 0 0.16 0.16 {}
L 4 92 -30 72 -30 {}
T {VDD} 50.2 -35 0 0 0.16 0.16 {}
L 4 92 -10 72 -10 {}
T {VNW} 50.2 -15 0 0 0.16 0.16 {}
L 4 92 10 72 10 {}
T {VPW} 50.2 5 0 0 0.16 0.16 {}
L 4 92 30 72 30 {}
T {VSS} 50.2 25 0 0 0.16 0.16 {}
B 5 -94 -42 -90 -38 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -22 -90 -18 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 -2 -90 2 {name=A3 dir=inout sim_pinnumber=3}
B 5 -94 18 -90 22 {name=A4 dir=inout sim_pinnumber=4}
B 5 -94 38 -90 42 {name=ZN dir=inout sim_pinnumber=5}
B 5 90 -32 94 -28 {name=VDD dir=inout sim_pinnumber=6}
B 5 90 -12 94 -8 {name=VNW dir=inout sim_pinnumber=7}
B 5 90 8 94 12 {name=VPW dir=inout sim_pinnumber=8}
B 5 90 28 94 32 {name=VSS dir=inout sim_pinnumber=9}
]
N 3958 22610 3938 22610 {lab=u_clock_div_counter_b4}
C {./lab_pin.sym} 3938 22610 0 0 {name=l1210_0 lab=u_clock_div_counter_b4}
N 3958 22630 3938 22630 {lab=u_clock_div_counter_b5}
C {./lab_pin.sym} 3938 22630 0 0 {name=l1210_1 lab=u_clock_div_counter_b5}
N 3958 22650 3938 22650 {lab=u_clock_div_counter_b6}
C {./lab_pin.sym} 3938 22650 0 0 {name=l1210_2 lab=u_clock_div_counter_b6}
N 3958 22670 3938 22670 {lab=n_0588}
C {./lab_pin.sym} 3938 22670 0 0 {name=l1210_3 lab=n_0588}
N 3958 22690 3938 22690 {lab=n_0591}
C {./lab_pin.sym} 3938 22690 0 0 {name=l1210_4 lab=n_0591}
N 4142 22620 4162 22620 {lab=VDD}
C {./lab_pin.sym} 4162 22620 0 1 {name=l1210_5 lab=VDD}
N 4142 22640 4162 22640 {lab=VDD}
C {./lab_pin.sym} 4162 22640 0 1 {name=l1210_6 lab=VDD}
N 4142 22660 4162 22660 {lab=VSS}
C {./lab_pin.sym} 4162 22660 0 1 {name=l1210_7 lab=VSS}
N 4142 22680 4162 22680 {lab=VSS}
C {./lab_pin.sym} 4162 22680 0 1 {name=l1210_8 lab=VSS}
C {./xnor2_1.sym} 4455 22650 0 0 {name=Xn_1152}
N 4363 22620 4343 22620 {lab=u_clock_div_counter_b6}
C {./lab_pin.sym} 4343 22620 0 0 {name=l1211_0 lab=u_clock_div_counter_b6}
N 4363 22640 4343 22640 {lab=n_0590}
C {./lab_pin.sym} 4343 22640 0 0 {name=l1211_1 lab=n_0590}
N 4363 22660 4343 22660 {lab=n_0143}
C {./lab_pin.sym} 4343 22660 0 0 {name=l1211_2 lab=n_0143}
N 4363 22680 4343 22680 {lab=VDD}
C {./lab_pin.sym} 4343 22680 0 0 {name=l1211_3 lab=VDD}
N 4547 22630 4567 22630 {lab=VDD}
C {./lab_pin.sym} 4567 22630 0 1 {name=l1211_4 lab=VDD}
N 4547 22650 4567 22650 {lab=VSS}
C {./lab_pin.sym} 4567 22650 0 1 {name=l1211_5 lab=VSS}
N 4547 22670 4567 22670 {lab=VSS}
C {./lab_pin.sym} 4567 22670 0 1 {name=l1211_6 lab=VSS}
C {./xnor2_1.sym} 0 22875 0 0 {name=Xn_1153}
N -92 22845 -112 22845 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} -112 22845 0 0 {name=l1212_0 lab=u_clock_div_counter_b7}
N -92 22865 -112 22865 {lab=n_0591}
C {./lab_pin.sym} -112 22865 0 0 {name=l1212_1 lab=n_0591}
N -92 22885 -112 22885 {lab=n_0144}
C {./lab_pin.sym} -112 22885 0 0 {name=l1212_2 lab=n_0144}
N -92 22905 -112 22905 {lab=VDD}
C {./lab_pin.sym} -112 22905 0 0 {name=l1212_3 lab=VDD}
N 92 22855 112 22855 {lab=VDD}
C {./lab_pin.sym} 112 22855 0 1 {name=l1212_4 lab=VDD}
N 92 22875 112 22875 {lab=VSS}
C {./lab_pin.sym} 112 22875 0 1 {name=l1212_5 lab=VSS}
N 92 22895 112 22895 {lab=VSS}
C {./lab_pin.sym} 112 22895 0 1 {name=l1212_6 lab=VSS}
C {./nand2_1.sym} 405 22875 0 0 {name=Xn_1154}
N 313 22845 293 22845 {lab=u_cas_int_out_int2_b0}
C {./lab_pin.sym} 293 22845 0 0 {name=l1213_0 lab=u_cas_int_out_int2_b0}
N 313 22865 293 22865 {lab=out_cas_int_b0}
C {./lab_pin.sym} 293 22865 0 0 {name=l1213_1 lab=out_cas_int_b0}
N 313 22885 293 22885 {lab=n_0592}
C {./lab_pin.sym} 293 22885 0 0 {name=l1213_2 lab=n_0592}
N 313 22905 293 22905 {lab=VDD}
C {./lab_pin.sym} 293 22905 0 0 {name=l1213_3 lab=VDD}
N 497 22855 517 22855 {lab=VDD}
C {./lab_pin.sym} 517 22855 0 1 {name=l1213_4 lab=VDD}
N 497 22875 517 22875 {lab=VSS}
C {./lab_pin.sym} 517 22875 0 1 {name=l1213_5 lab=VSS}
N 497 22895 517 22895 {lab=VSS}
C {./lab_pin.sym} 517 22895 0 1 {name=l1213_6 lab=VSS}
C {./nand2_1.sym} 810 22875 0 0 {name=Xn_1155}
N 718 22845 698 22845 {lab=u_cas_int_out_int2_b1}
C {./lab_pin.sym} 698 22845 0 0 {name=l1214_0 lab=u_cas_int_out_int2_b1}
N 718 22865 698 22865 {lab=out_cas_int_b1}
C {./lab_pin.sym} 698 22865 0 0 {name=l1214_1 lab=out_cas_int_b1}
N 718 22885 698 22885 {lab=n_0593}
C {./lab_pin.sym} 698 22885 0 0 {name=l1214_2 lab=n_0593}
N 718 22905 698 22905 {lab=VDD}
C {./lab_pin.sym} 698 22905 0 0 {name=l1214_3 lab=VDD}
N 902 22855 922 22855 {lab=VDD}
C {./lab_pin.sym} 922 22855 0 1 {name=l1214_4 lab=VDD}
N 902 22875 922 22875 {lab=VSS}
C {./lab_pin.sym} 922 22875 0 1 {name=l1214_5 lab=VSS}
N 902 22895 922 22895 {lab=VSS}
C {./lab_pin.sym} 922 22895 0 1 {name=l1214_6 lab=VSS}
C {./nor2_1.sym} 1215 22875 0 0 {name=Xn_1156}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__nor2_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -50 72 -50 {}
L 4 72 -50 72 50 {}
L 4 72 50 -72 50 {}
L 4 -72 50 -72 -50 {}
T {@name} -72 -70 0 0 0.33 0.33 {}
T {nor2_1} -68 39 0 0 0.2 0.2 {}
L 4 -92 -30 -72 -30 {}
T {A1} -66 -35 0 0 0.16 0.16 {}
L 4 -92 -10 -72 -10 {}
T {A2} -66 -15 0 0 0.16 0.16 {}
L 4 -92 10 -72 10 {}
T {ZN} -66 5 0 0 0.16 0.16 {}
L 4 -92 30 -72 30 {}
T {VDD} -66 25 0 0 0.16 0.16 {}
L 4 92 -20 72 -20 {}
T {VNW} 50.2 -25 0 0 0.16 0.16 {}
L 4 92 0 72 0 {}
T {VPW} 50.2 -5 0 0 0.16 0.16 {}
L 4 92 20 72 20 {}
T {VSS} 50.2 15 0 0 0.16 0.16 {}
B 5 -94 -32 -90 -28 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -12 -90 -8 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 8 -90 12 {name=ZN dir=inout sim_pinnumber=3}
B 5 -94 28 -90 32 {name=VDD dir=inout sim_pinnumber=4}
B 5 90 -22 94 -18 {name=VNW dir=inout sim_pinnumber=5}
B 5 90 -2 94 2 {name=VPW dir=inout sim_pinnumber=6}
B 5 90 18 94 22 {name=VSS dir=inout sim_pinnumber=7}
]
N 1123 22845 1103 22845 {lab=u_cas_int_out_int2_b1}
C {./lab_pin.sym} 1103 22845 0 0 {name=l1215_0 lab=u_cas_int_out_int2_b1}
N 1123 22865 1103 22865 {lab=out_cas_int_b1}
C {./lab_pin.sym} 1103 22865 0 0 {name=l1215_1 lab=out_cas_int_b1}
N 1123 22885 1103 22885 {lab=n_0594}
C {./lab_pin.sym} 1103 22885 0 0 {name=l1215_2 lab=n_0594}
N 1123 22905 1103 22905 {lab=VDD}
C {./lab_pin.sym} 1103 22905 0 0 {name=l1215_3 lab=VDD}
N 1307 22855 1327 22855 {lab=VDD}
C {./lab_pin.sym} 1327 22855 0 1 {name=l1215_4 lab=VDD}
N 1307 22875 1327 22875 {lab=VSS}
C {./lab_pin.sym} 1327 22875 0 1 {name=l1215_5 lab=VSS}
N 1307 22895 1327 22895 {lab=VSS}
C {./lab_pin.sym} 1327 22895 0 1 {name=l1215_6 lab=VSS}
C {./xor3_1.sym} 1620 22875 0 0 {name=Xn_1157}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__xor3_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -50 72 -50 {}
L 4 72 -50 72 50 {}
L 4 72 50 -72 50 {}
L 4 -72 50 -72 -50 {}
T {@name} -72 -70 0 0 0.33 0.33 {}
T {xor3_1} -68 39 0 0 0.2 0.2 {}
L 4 -92 -30 -72 -30 {}
T {A1} -66 -35 0 0 0.16 0.16 {}
L 4 -92 -10 -72 -10 {}
T {A2} -66 -15 0 0 0.16 0.16 {}
L 4 -92 10 -72 10 {}
T {A3} -66 5 0 0 0.16 0.16 {}
L 4 -92 30 -72 30 {}
T {Z} -66 25 0 0 0.16 0.16 {}
L 4 92 -30 72 -30 {}
T {VDD} 50.2 -35 0 0 0.16 0.16 {}
L 4 92 -10 72 -10 {}
T {VNW} 50.2 -15 0 0 0.16 0.16 {}
L 4 92 10 72 10 {}
T {VPW} 50.2 5 0 0 0.16 0.16 {}
L 4 92 30 72 30 {}
T {VSS} 50.2 25 0 0 0.16 0.16 {}
B 5 -94 -32 -90 -28 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -12 -90 -8 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 8 -90 12 {name=A3 dir=inout sim_pinnumber=3}
B 5 -94 28 -90 32 {name=Z dir=inout sim_pinnumber=4}
B 5 90 -32 94 -28 {name=VDD dir=inout sim_pinnumber=5}
B 5 90 -12 94 -8 {name=VNW dir=inout sim_pinnumber=6}
B 5 90 8 94 12 {name=VPW dir=inout sim_pinnumber=7}
B 5 90 28 94 32 {name=VSS dir=inout sim_pinnumber=8}
]
N 1528 22845 1508 22845 {lab=u_cas_int_out_int2_b1}
C {./lab_pin.sym} 1508 22845 0 0 {name=l1216_0 lab=u_cas_int_out_int2_b1}
N 1528 22865 1508 22865 {lab=n_0478}
C {./lab_pin.sym} 1508 22865 0 0 {name=l1216_1 lab=n_0478}
N 1528 22885 1508 22885 {lab=n_0592}
C {./lab_pin.sym} 1508 22885 0 0 {name=l1216_2 lab=n_0592}
N 1528 22905 1508 22905 {lab=n_0123}
C {./lab_pin.sym} 1508 22905 0 0 {name=l1216_3 lab=n_0123}
N 1712 22845 1732 22845 {lab=VDD}
C {./lab_pin.sym} 1732 22845 0 1 {name=l1216_4 lab=VDD}
N 1712 22865 1732 22865 {lab=VDD}
C {./lab_pin.sym} 1732 22865 0 1 {name=l1216_5 lab=VDD}
N 1712 22885 1732 22885 {lab=VSS}
C {./lab_pin.sym} 1732 22885 0 1 {name=l1216_6 lab=VSS}
N 1712 22905 1732 22905 {lab=VSS}
C {./lab_pin.sym} 1732 22905 0 1 {name=l1216_7 lab=VSS}
C {./nor2_1.sym} 2025 22875 0 0 {name=Xn_1158}
N 1933 22845 1913 22845 {lab=u_cas_int_out_int2_b2}
C {./lab_pin.sym} 1913 22845 0 0 {name=l1217_0 lab=u_cas_int_out_int2_b2}
N 1933 22865 1913 22865 {lab=out_cas_int_b2}
C {./lab_pin.sym} 1913 22865 0 0 {name=l1217_1 lab=out_cas_int_b2}
N 1933 22885 1913 22885 {lab=n_0595}
C {./lab_pin.sym} 1913 22885 0 0 {name=l1217_2 lab=n_0595}
N 1933 22905 1913 22905 {lab=VDD}
C {./lab_pin.sym} 1913 22905 0 0 {name=l1217_3 lab=VDD}
N 2117 22855 2137 22855 {lab=VDD}
C {./lab_pin.sym} 2137 22855 0 1 {name=l1217_4 lab=VDD}
N 2117 22875 2137 22875 {lab=VSS}
C {./lab_pin.sym} 2137 22875 0 1 {name=l1217_5 lab=VSS}
N 2117 22895 2137 22895 {lab=VSS}
C {./lab_pin.sym} 2137 22895 0 1 {name=l1217_6 lab=VSS}
C {./and2_1.sym} 2430 22875 0 0 {name=Xn_1159}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__and2_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -50 72 -50 {}
L 4 72 -50 72 50 {}
L 4 72 50 -72 50 {}
L 4 -72 50 -72 -50 {}
T {@name} -72 -70 0 0 0.33 0.33 {}
T {and2_1} -68 39 0 0 0.2 0.2 {}
L 4 -92 -30 -72 -30 {}
T {A1} -66 -35 0 0 0.16 0.16 {}
L 4 -92 -10 -72 -10 {}
T {A2} -66 -15 0 0 0.16 0.16 {}
L 4 -92 10 -72 10 {}
T {Z} -66 5 0 0 0.16 0.16 {}
L 4 -92 30 -72 30 {}
T {VDD} -66 25 0 0 0.16 0.16 {}
L 4 92 -20 72 -20 {}
T {VNW} 50.2 -25 0 0 0.16 0.16 {}
L 4 92 0 72 0 {}
T {VPW} 50.2 -5 0 0 0.16 0.16 {}
L 4 92 20 72 20 {}
T {VSS} 50.2 15 0 0 0.16 0.16 {}
B 5 -94 -32 -90 -28 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -12 -90 -8 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 8 -90 12 {name=Z dir=inout sim_pinnumber=3}
B 5 -94 28 -90 32 {name=VDD dir=inout sim_pinnumber=4}
B 5 90 -22 94 -18 {name=VNW dir=inout sim_pinnumber=5}
B 5 90 -2 94 2 {name=VPW dir=inout sim_pinnumber=6}
B 5 90 18 94 22 {name=VSS dir=inout sim_pinnumber=7}
]
N 2338 22845 2318 22845 {lab=u_cas_int_out_int2_b2}
C {./lab_pin.sym} 2318 22845 0 0 {name=l1218_0 lab=u_cas_int_out_int2_b2}
N 2338 22865 2318 22865 {lab=out_cas_int_b2}
C {./lab_pin.sym} 2318 22865 0 0 {name=l1218_1 lab=out_cas_int_b2}
N 2338 22885 2318 22885 {lab=n_0596}
C {./lab_pin.sym} 2318 22885 0 0 {name=l1218_2 lab=n_0596}
N 2338 22905 2318 22905 {lab=VDD}
C {./lab_pin.sym} 2318 22905 0 0 {name=l1218_3 lab=VDD}
N 2522 22855 2542 22855 {lab=VDD}
C {./lab_pin.sym} 2542 22855 0 1 {name=l1218_4 lab=VDD}
N 2522 22875 2542 22875 {lab=VSS}
C {./lab_pin.sym} 2542 22875 0 1 {name=l1218_5 lab=VSS}
N 2522 22895 2542 22895 {lab=VSS}
C {./lab_pin.sym} 2542 22895 0 1 {name=l1218_6 lab=VSS}
C {./nor2_1.sym} 2835 22875 0 0 {name=Xn_1160}
N 2743 22845 2723 22845 {lab=n_0595}
C {./lab_pin.sym} 2723 22845 0 0 {name=l1219_0 lab=n_0595}
N 2743 22865 2723 22865 {lab=n_0596}
C {./lab_pin.sym} 2723 22865 0 0 {name=l1219_1 lab=n_0596}
N 2743 22885 2723 22885 {lab=n_0597}
C {./lab_pin.sym} 2723 22885 0 0 {name=l1219_2 lab=n_0597}
N 2743 22905 2723 22905 {lab=VDD}
C {./lab_pin.sym} 2723 22905 0 0 {name=l1219_3 lab=VDD}
N 2927 22855 2947 22855 {lab=VDD}
C {./lab_pin.sym} 2947 22855 0 1 {name=l1219_4 lab=VDD}
N 2927 22875 2947 22875 {lab=VSS}
C {./lab_pin.sym} 2947 22875 0 1 {name=l1219_5 lab=VSS}
N 2927 22895 2947 22895 {lab=VSS}
C {./lab_pin.sym} 2947 22895 0 1 {name=l1219_6 lab=VSS}
C {./oai211_1.sym} 3240 22875 0 0 {name=Xn_1161}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__oai211_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -60 72 -60 {}
L 4 72 -60 72 60 {}
L 4 72 60 -72 60 {}
L 4 -72 60 -72 -60 {}
T {@name} -72 -80 0 0 0.33 0.33 {}
T {oai211_1} -68 49 0 0 0.2 0.2 {}
L 4 -92 -40 -72 -40 {}
T {A1} -66 -45 0 0 0.16 0.16 {}
L 4 -92 -20 -72 -20 {}
T {A2} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {B} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {C} -66 15 0 0 0.16 0.16 {}
L 4 -92 40 -72 40 {}
T {ZN} -66 35 0 0 0.16 0.16 {}
L 4 92 -30 72 -30 {}
T {VDD} 50.2 -35 0 0 0.16 0.16 {}
L 4 92 -10 72 -10 {}
T {VNW} 50.2 -15 0 0 0.16 0.16 {}
L 4 92 10 72 10 {}
T {VPW} 50.2 5 0 0 0.16 0.16 {}
L 4 92 30 72 30 {}
T {VSS} 50.2 25 0 0 0.16 0.16 {}
B 5 -94 -42 -90 -38 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -22 -90 -18 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 -2 -90 2 {name=B dir=inout sim_pinnumber=3}
B 5 -94 18 -90 22 {name=C dir=inout sim_pinnumber=4}
B 5 -94 38 -90 42 {name=ZN dir=inout sim_pinnumber=5}
B 5 90 -32 94 -28 {name=VDD dir=inout sim_pinnumber=6}
B 5 90 -12 94 -8 {name=VNW dir=inout sim_pinnumber=7}
B 5 90 8 94 12 {name=VPW dir=inout sim_pinnumber=8}
B 5 90 28 94 32 {name=VSS dir=inout sim_pinnumber=9}
]
N 3148 22835 3128 22835 {lab=u_cas_int_out_int2_b1}
C {./lab_pin.sym} 3128 22835 0 0 {name=l1220_0 lab=u_cas_int_out_int2_b1}
N 3148 22855 3128 22855 {lab=out_cas_int_b1}
C {./lab_pin.sym} 3128 22855 0 0 {name=l1220_1 lab=out_cas_int_b1}
N 3148 22875 3128 22875 {lab=u_cas_int_out_int2_b0}
C {./lab_pin.sym} 3128 22875 0 0 {name=l1220_2 lab=u_cas_int_out_int2_b0}
N 3148 22895 3128 22895 {lab=out_cas_int_b0}
C {./lab_pin.sym} 3128 22895 0 0 {name=l1220_3 lab=out_cas_int_b0}
N 3148 22915 3128 22915 {lab=n_0598}
C {./lab_pin.sym} 3128 22915 0 0 {name=l1220_4 lab=n_0598}
N 3332 22845 3352 22845 {lab=VDD}
C {./lab_pin.sym} 3352 22845 0 1 {name=l1220_5 lab=VDD}
N 3332 22865 3352 22865 {lab=VDD}
C {./lab_pin.sym} 3352 22865 0 1 {name=l1220_6 lab=VDD}
N 3332 22885 3352 22885 {lab=VSS}
C {./lab_pin.sym} 3352 22885 0 1 {name=l1220_7 lab=VSS}
N 3332 22905 3352 22905 {lab=VSS}
C {./lab_pin.sym} 3352 22905 0 1 {name=l1220_8 lab=VSS}
C {./oai21_1.sym} 3645 22875 0 0 {name=Xn_1162}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__oai21_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -50 72 -50 {}
L 4 72 -50 72 50 {}
L 4 72 50 -72 50 {}
L 4 -72 50 -72 -50 {}
T {@name} -72 -70 0 0 0.33 0.33 {}
T {oai21_1} -68 39 0 0 0.2 0.2 {}
L 4 -92 -30 -72 -30 {}
T {A1} -66 -35 0 0 0.16 0.16 {}
L 4 -92 -10 -72 -10 {}
T {A2} -66 -15 0 0 0.16 0.16 {}
L 4 -92 10 -72 10 {}
T {B} -66 5 0 0 0.16 0.16 {}
L 4 -92 30 -72 30 {}
T {ZN} -66 25 0 0 0.16 0.16 {}
L 4 92 -30 72 -30 {}
T {VDD} 50.2 -35 0 0 0.16 0.16 {}
L 4 92 -10 72 -10 {}
T {VNW} 50.2 -15 0 0 0.16 0.16 {}
L 4 92 10 72 10 {}
T {VPW} 50.2 5 0 0 0.16 0.16 {}
L 4 92 30 72 30 {}
T {VSS} 50.2 25 0 0 0.16 0.16 {}
B 5 -94 -32 -90 -28 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -12 -90 -8 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 8 -90 12 {name=B dir=inout sim_pinnumber=3}
B 5 -94 28 -90 32 {name=ZN dir=inout sim_pinnumber=4}
B 5 90 -32 94 -28 {name=VDD dir=inout sim_pinnumber=5}
B 5 90 -12 94 -8 {name=VNW dir=inout sim_pinnumber=6}
B 5 90 8 94 12 {name=VPW dir=inout sim_pinnumber=7}
B 5 90 28 94 32 {name=VSS dir=inout sim_pinnumber=8}
]
N 3553 22845 3533 22845 {lab=n_0594}
C {./lab_pin.sym} 3533 22845 0 0 {name=l1221_0 lab=n_0594}
N 3553 22865 3533 22865 {lab=n_0592}
C {./lab_pin.sym} 3533 22865 0 0 {name=l1221_1 lab=n_0592}
N 3553 22885 3533 22885 {lab=n_0593}
C {./lab_pin.sym} 3533 22885 0 0 {name=l1221_2 lab=n_0593}
N 3553 22905 3533 22905 {lab=n_0599}
C {./lab_pin.sym} 3533 22905 0 0 {name=l1221_3 lab=n_0599}
N 3737 22845 3757 22845 {lab=VDD}
C {./lab_pin.sym} 3757 22845 0 1 {name=l1221_4 lab=VDD}
N 3737 22865 3757 22865 {lab=VDD}
C {./lab_pin.sym} 3757 22865 0 1 {name=l1221_5 lab=VDD}
N 3737 22885 3757 22885 {lab=VSS}
C {./lab_pin.sym} 3757 22885 0 1 {name=l1221_6 lab=VSS}
N 3737 22905 3757 22905 {lab=VSS}
C {./lab_pin.sym} 3757 22905 0 1 {name=l1221_7 lab=VSS}
C {./nor2_1.sym} 4050 22875 0 0 {name=Xn_1163}
N 3958 22845 3938 22845 {lab=n_0597}
C {./lab_pin.sym} 3938 22845 0 0 {name=l1222_0 lab=n_0597}
N 3958 22865 3938 22865 {lab=n_0599}
C {./lab_pin.sym} 3938 22865 0 0 {name=l1222_1 lab=n_0599}
N 3958 22885 3938 22885 {lab=n_0600}
C {./lab_pin.sym} 3938 22885 0 0 {name=l1222_2 lab=n_0600}
N 3958 22905 3938 22905 {lab=VDD}
C {./lab_pin.sym} 3938 22905 0 0 {name=l1222_3 lab=VDD}
N 4142 22855 4162 22855 {lab=VDD}
C {./lab_pin.sym} 4162 22855 0 1 {name=l1222_4 lab=VDD}
N 4142 22875 4162 22875 {lab=VSS}
C {./lab_pin.sym} 4162 22875 0 1 {name=l1222_5 lab=VSS}
N 4142 22895 4162 22895 {lab=VSS}
C {./lab_pin.sym} 4162 22895 0 1 {name=l1222_6 lab=VSS}
C {./aoi211_1.sym} 4455 22875 0 0 {name=Xn_1164}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__aoi211_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -60 72 -60 {}
L 4 72 -60 72 60 {}
L 4 72 60 -72 60 {}
L 4 -72 60 -72 -60 {}
T {@name} -72 -80 0 0 0.33 0.33 {}
T {aoi211_1} -68 49 0 0 0.2 0.2 {}
L 4 -92 -40 -72 -40 {}
T {A1} -66 -45 0 0 0.16 0.16 {}
L 4 -92 -20 -72 -20 {}
T {A2} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {B} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {C} -66 15 0 0 0.16 0.16 {}
L 4 -92 40 -72 40 {}
T {ZN} -66 35 0 0 0.16 0.16 {}
L 4 92 -30 72 -30 {}
T {VDD} 50.2 -35 0 0 0.16 0.16 {}
L 4 92 -10 72 -10 {}
T {VNW} 50.2 -15 0 0 0.16 0.16 {}
L 4 92 10 72 10 {}
T {VPW} 50.2 5 0 0 0.16 0.16 {}
L 4 92 30 72 30 {}
T {VSS} 50.2 25 0 0 0.16 0.16 {}
B 5 -94 -42 -90 -38 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -22 -90 -18 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 -2 -90 2 {name=B dir=inout sim_pinnumber=3}
B 5 -94 18 -90 22 {name=C dir=inout sim_pinnumber=4}
B 5 -94 38 -90 42 {name=ZN dir=inout sim_pinnumber=5}
B 5 90 -32 94 -28 {name=VDD dir=inout sim_pinnumber=6}
B 5 90 -12 94 -8 {name=VNW dir=inout sim_pinnumber=7}
B 5 90 8 94 12 {name=VPW dir=inout sim_pinnumber=8}
B 5 90 28 94 32 {name=VSS dir=inout sim_pinnumber=9}
]
N 4363 22835 4343 22835 {lab=n_0593}
C {./lab_pin.sym} 4343 22835 0 0 {name=l1223_0 lab=n_0593}
N 4363 22855 4343 22855 {lab=n_0598}
C {./lab_pin.sym} 4343 22855 0 0 {name=l1223_1 lab=n_0598}
N 4363 22875 4343 22875 {lab=n_0596}
C {./lab_pin.sym} 4343 22875 0 0 {name=l1223_2 lab=n_0596}
N 4363 22895 4343 22895 {lab=n_0595}
C {./lab_pin.sym} 4343 22895 0 0 {name=l1223_3 lab=n_0595}
N 4363 22915 4343 22915 {lab=n_0601}
C {./lab_pin.sym} 4343 22915 0 0 {name=l1223_4 lab=n_0601}
N 4547 22845 4567 22845 {lab=VDD}
C {./lab_pin.sym} 4567 22845 0 1 {name=l1223_5 lab=VDD}
N 4547 22865 4567 22865 {lab=VDD}
C {./lab_pin.sym} 4567 22865 0 1 {name=l1223_6 lab=VDD}
N 4547 22885 4567 22885 {lab=VSS}
C {./lab_pin.sym} 4567 22885 0 1 {name=l1223_7 lab=VSS}
N 4547 22905 4567 22905 {lab=VSS}
C {./lab_pin.sym} 4567 22905 0 1 {name=l1223_8 lab=VSS}
C {./nand2_1.sym} 0 23100 0 0 {name=Xn_1165}
N -92 23070 -112 23070 {lab=n_0597}
C {./lab_pin.sym} -112 23070 0 0 {name=l1224_0 lab=n_0597}
N -92 23090 -112 23090 {lab=n_0599}
C {./lab_pin.sym} -112 23090 0 0 {name=l1224_1 lab=n_0599}
N -92 23110 -112 23110 {lab=n_0602}
C {./lab_pin.sym} -112 23110 0 0 {name=l1224_2 lab=n_0602}
N -92 23130 -112 23130 {lab=VDD}
C {./lab_pin.sym} -112 23130 0 0 {name=l1224_3 lab=VDD}
N 92 23080 112 23080 {lab=VDD}
C {./lab_pin.sym} 112 23080 0 1 {name=l1224_4 lab=VDD}
N 92 23100 112 23100 {lab=VSS}
C {./lab_pin.sym} 112 23100 0 1 {name=l1224_5 lab=VSS}
N 92 23120 112 23120 {lab=VSS}
C {./lab_pin.sym} 112 23120 0 1 {name=l1224_6 lab=VSS}
C {./nor2_1.sym} 405 23100 0 0 {name=Xn_1166}
N 313 23070 293 23070 {lab=n_0600}
C {./lab_pin.sym} 293 23070 0 0 {name=l1225_0 lab=n_0600}
N 313 23090 293 23090 {lab=n_0601}
C {./lab_pin.sym} 293 23090 0 0 {name=l1225_1 lab=n_0601}
N 313 23110 293 23110 {lab=n_0129}
C {./lab_pin.sym} 293 23110 0 0 {name=l1225_2 lab=n_0129}
N 313 23130 293 23130 {lab=VDD}
C {./lab_pin.sym} 293 23130 0 0 {name=l1225_3 lab=VDD}
N 497 23080 517 23080 {lab=VDD}
C {./lab_pin.sym} 517 23080 0 1 {name=l1225_4 lab=VDD}
N 497 23100 517 23100 {lab=VSS}
C {./lab_pin.sym} 517 23100 0 1 {name=l1225_5 lab=VSS}
N 497 23120 517 23120 {lab=VSS}
C {./lab_pin.sym} 517 23120 0 1 {name=l1225_6 lab=VSS}
C {./aoi21_1.sym} 810 23100 0 0 {name=Xn_1167}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__aoi21_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -50 72 -50 {}
L 4 72 -50 72 50 {}
L 4 72 50 -72 50 {}
L 4 -72 50 -72 -50 {}
T {@name} -72 -70 0 0 0.33 0.33 {}
T {aoi21_1} -68 39 0 0 0.2 0.2 {}
L 4 -92 -30 -72 -30 {}
T {A1} -66 -35 0 0 0.16 0.16 {}
L 4 -92 -10 -72 -10 {}
T {A2} -66 -15 0 0 0.16 0.16 {}
L 4 -92 10 -72 10 {}
T {B} -66 5 0 0 0.16 0.16 {}
L 4 -92 30 -72 30 {}
T {ZN} -66 25 0 0 0.16 0.16 {}
L 4 92 -30 72 -30 {}
T {VDD} 50.2 -35 0 0 0.16 0.16 {}
L 4 92 -10 72 -10 {}
T {VNW} 50.2 -15 0 0 0.16 0.16 {}
L 4 92 10 72 10 {}
T {VPW} 50.2 5 0 0 0.16 0.16 {}
L 4 92 30 72 30 {}
T {VSS} 50.2 25 0 0 0.16 0.16 {}
B 5 -94 -32 -90 -28 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -12 -90 -8 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 8 -90 12 {name=B dir=inout sim_pinnumber=3}
B 5 -94 28 -90 32 {name=ZN dir=inout sim_pinnumber=4}
B 5 90 -32 94 -28 {name=VDD dir=inout sim_pinnumber=5}
B 5 90 -12 94 -8 {name=VNW dir=inout sim_pinnumber=6}
B 5 90 8 94 12 {name=VPW dir=inout sim_pinnumber=7}
B 5 90 28 94 32 {name=VSS dir=inout sim_pinnumber=8}
]
N 718 23070 698 23070 {lab=n_0597}
C {./lab_pin.sym} 698 23070 0 0 {name=l1226_0 lab=n_0597}
N 718 23090 698 23090 {lab=n_0599}
C {./lab_pin.sym} 698 23090 0 0 {name=l1226_1 lab=n_0599}
N 718 23110 698 23110 {lab=n_0596}
C {./lab_pin.sym} 698 23110 0 0 {name=l1226_2 lab=n_0596}
N 718 23130 698 23130 {lab=n_0603}
C {./lab_pin.sym} 698 23130 0 0 {name=l1226_3 lab=n_0603}
N 902 23070 922 23070 {lab=VDD}
C {./lab_pin.sym} 922 23070 0 1 {name=l1226_4 lab=VDD}
N 902 23090 922 23090 {lab=VDD}
C {./lab_pin.sym} 922 23090 0 1 {name=l1226_5 lab=VDD}
N 902 23110 922 23110 {lab=VSS}
C {./lab_pin.sym} 922 23110 0 1 {name=l1226_6 lab=VSS}
N 902 23130 922 23130 {lab=VSS}
C {./lab_pin.sym} 922 23130 0 1 {name=l1226_7 lab=VSS}
C {./nor2_1.sym} 1215 23100 0 0 {name=Xn_1168}
N 1123 23070 1103 23070 {lab=u_cas_int_out_int2_b3}
C {./lab_pin.sym} 1103 23070 0 0 {name=l1227_0 lab=u_cas_int_out_int2_b3}
N 1123 23090 1103 23090 {lab=out_cas_int_b3}
C {./lab_pin.sym} 1103 23090 0 0 {name=l1227_1 lab=out_cas_int_b3}
N 1123 23110 1103 23110 {lab=n_0604}
C {./lab_pin.sym} 1103 23110 0 0 {name=l1227_2 lab=n_0604}
N 1123 23130 1103 23130 {lab=VDD}
C {./lab_pin.sym} 1103 23130 0 0 {name=l1227_3 lab=VDD}
N 1307 23080 1327 23080 {lab=VDD}
C {./lab_pin.sym} 1327 23080 0 1 {name=l1227_4 lab=VDD}
N 1307 23100 1327 23100 {lab=VSS}
C {./lab_pin.sym} 1327 23100 0 1 {name=l1227_5 lab=VSS}
N 1307 23120 1327 23120 {lab=VSS}
C {./lab_pin.sym} 1327 23120 0 1 {name=l1227_6 lab=VSS}
C {./or2_1.sym} 1620 23100 0 0 {name=Xn_1169}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__or2_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -50 72 -50 {}
L 4 72 -50 72 50 {}
L 4 72 50 -72 50 {}
L 4 -72 50 -72 -50 {}
T {@name} -72 -70 0 0 0.33 0.33 {}
T {or2_1} -68 39 0 0 0.2 0.2 {}
L 4 -92 -30 -72 -30 {}
T {A1} -66 -35 0 0 0.16 0.16 {}
L 4 -92 -10 -72 -10 {}
T {A2} -66 -15 0 0 0.16 0.16 {}
L 4 -92 10 -72 10 {}
T {Z} -66 5 0 0 0.16 0.16 {}
L 4 -92 30 -72 30 {}
T {VDD} -66 25 0 0 0.16 0.16 {}
L 4 92 -20 72 -20 {}
T {VNW} 50.2 -25 0 0 0.16 0.16 {}
L 4 92 0 72 0 {}
T {VPW} 50.2 -5 0 0 0.16 0.16 {}
L 4 92 20 72 20 {}
T {VSS} 50.2 15 0 0 0.16 0.16 {}
B 5 -94 -32 -90 -28 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -12 -90 -8 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 8 -90 12 {name=Z dir=inout sim_pinnumber=3}
B 5 -94 28 -90 32 {name=VDD dir=inout sim_pinnumber=4}
B 5 90 -22 94 -18 {name=VNW dir=inout sim_pinnumber=5}
B 5 90 -2 94 2 {name=VPW dir=inout sim_pinnumber=6}
B 5 90 18 94 22 {name=VSS dir=inout sim_pinnumber=7}
]
N 1528 23070 1508 23070 {lab=u_cas_int_out_int2_b3}
C {./lab_pin.sym} 1508 23070 0 0 {name=l1228_0 lab=u_cas_int_out_int2_b3}
N 1528 23090 1508 23090 {lab=out_cas_int_b3}
C {./lab_pin.sym} 1508 23090 0 0 {name=l1228_1 lab=out_cas_int_b3}
N 1528 23110 1508 23110 {lab=n_0605}
C {./lab_pin.sym} 1508 23110 0 0 {name=l1228_2 lab=n_0605}
N 1528 23130 1508 23130 {lab=VDD}
C {./lab_pin.sym} 1508 23130 0 0 {name=l1228_3 lab=VDD}
N 1712 23080 1732 23080 {lab=VDD}
C {./lab_pin.sym} 1732 23080 0 1 {name=l1228_4 lab=VDD}
N 1712 23100 1732 23100 {lab=VSS}
C {./lab_pin.sym} 1732 23100 0 1 {name=l1228_5 lab=VSS}
N 1712 23120 1732 23120 {lab=VSS}
C {./lab_pin.sym} 1732 23120 0 1 {name=l1228_6 lab=VSS}
C {./xor3_1.sym} 2025 23100 0 0 {name=Xn_1170}
N 1933 23070 1913 23070 {lab=u_cas_int_out_int2_b3}
C {./lab_pin.sym} 1913 23070 0 0 {name=l1229_0 lab=u_cas_int_out_int2_b3}
N 1933 23090 1913 23090 {lab=n_0481}
C {./lab_pin.sym} 1913 23090 0 0 {name=l1229_1 lab=n_0481}
N 1933 23110 1913 23110 {lab=n_0603}
C {./lab_pin.sym} 1913 23110 0 0 {name=l1229_2 lab=n_0603}
N 1933 23130 1913 23130 {lab=n_0130}
C {./lab_pin.sym} 1913 23130 0 0 {name=l1229_3 lab=n_0130}
N 2117 23070 2137 23070 {lab=VDD}
C {./lab_pin.sym} 2137 23070 0 1 {name=l1229_4 lab=VDD}
N 2117 23090 2137 23090 {lab=VDD}
C {./lab_pin.sym} 2137 23090 0 1 {name=l1229_5 lab=VDD}
N 2117 23110 2137 23110 {lab=VSS}
C {./lab_pin.sym} 2137 23110 0 1 {name=l1229_6 lab=VSS}
N 2117 23130 2137 23130 {lab=VSS}
C {./lab_pin.sym} 2137 23130 0 1 {name=l1229_7 lab=VSS}
C {./aoi22_1.sym} 2430 23100 0 0 {name=Xn_1171}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__aoi22_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -60 72 -60 {}
L 4 72 -60 72 60 {}
L 4 72 60 -72 60 {}
L 4 -72 60 -72 -60 {}
T {@name} -72 -80 0 0 0.33 0.33 {}
T {aoi22_1} -68 49 0 0 0.2 0.2 {}
L 4 -92 -40 -72 -40 {}
T {A1} -66 -45 0 0 0.16 0.16 {}
L 4 -92 -20 -72 -20 {}
T {A2} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {B1} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {B2} -66 15 0 0 0.16 0.16 {}
L 4 -92 40 -72 40 {}
T {ZN} -66 35 0 0 0.16 0.16 {}
L 4 92 -30 72 -30 {}
T {VDD} 50.2 -35 0 0 0.16 0.16 {}
L 4 92 -10 72 -10 {}
T {VNW} 50.2 -15 0 0 0.16 0.16 {}
L 4 92 10 72 10 {}
T {VPW} 50.2 5 0 0 0.16 0.16 {}
L 4 92 30 72 30 {}
T {VSS} 50.2 25 0 0 0.16 0.16 {}
B 5 -94 -42 -90 -38 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -22 -90 -18 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 -2 -90 2 {name=B1 dir=inout sim_pinnumber=3}
B 5 -94 18 -90 22 {name=B2 dir=inout sim_pinnumber=4}
B 5 -94 38 -90 42 {name=ZN dir=inout sim_pinnumber=5}
B 5 90 -32 94 -28 {name=VDD dir=inout sim_pinnumber=6}
B 5 90 -12 94 -8 {name=VNW dir=inout sim_pinnumber=7}
B 5 90 8 94 12 {name=VPW dir=inout sim_pinnumber=8}
B 5 90 28 94 32 {name=VSS dir=inout sim_pinnumber=9}
]
N 2338 23060 2318 23060 {lab=u_cas_int_out_int2_b2}
C {./lab_pin.sym} 2318 23060 0 0 {name=l1230_0 lab=u_cas_int_out_int2_b2}
N 2338 23080 2318 23080 {lab=out_cas_int_b2}
C {./lab_pin.sym} 2318 23080 0 0 {name=l1230_1 lab=out_cas_int_b2}
N 2338 23100 2318 23100 {lab=u_cas_int_out_int2_b3}
C {./lab_pin.sym} 2318 23100 0 0 {name=l1230_2 lab=u_cas_int_out_int2_b3}
N 2338 23120 2318 23120 {lab=out_cas_int_b3}
C {./lab_pin.sym} 2318 23120 0 0 {name=l1230_3 lab=out_cas_int_b3}
N 2338 23140 2318 23140 {lab=n_0606}
C {./lab_pin.sym} 2318 23140 0 0 {name=l1230_4 lab=n_0606}
N 2522 23070 2542 23070 {lab=VDD}
C {./lab_pin.sym} 2542 23070 0 1 {name=l1230_5 lab=VDD}
N 2522 23090 2542 23090 {lab=VDD}
C {./lab_pin.sym} 2542 23090 0 1 {name=l1230_6 lab=VDD}
N 2522 23110 2542 23110 {lab=VSS}
C {./lab_pin.sym} 2542 23110 0 1 {name=l1230_7 lab=VSS}
N 2522 23130 2542 23130 {lab=VSS}
C {./lab_pin.sym} 2542 23130 0 1 {name=l1230_8 lab=VSS}
C {./clkinv_1.sym} 2835 23100 0 0 {name=Xn_1172}
N 2743 23080 2723 23080 {lab=n_0606}
C {./lab_pin.sym} 2723 23080 0 0 {name=l1231_0 lab=n_0606}
N 2743 23100 2723 23100 {lab=n_0607}
C {./lab_pin.sym} 2723 23100 0 0 {name=l1231_1 lab=n_0607}
N 2743 23120 2723 23120 {lab=VDD}
C {./lab_pin.sym} 2723 23120 0 0 {name=l1231_2 lab=VDD}
N 2927 23080 2947 23080 {lab=VDD}
C {./lab_pin.sym} 2947 23080 0 1 {name=l1231_3 lab=VDD}
N 2927 23100 2947 23100 {lab=VSS}
C {./lab_pin.sym} 2947 23100 0 1 {name=l1231_4 lab=VSS}
N 2927 23120 2947 23120 {lab=VSS}
C {./lab_pin.sym} 2947 23120 0 1 {name=l1231_5 lab=VSS}
C {./oai21_1.sym} 3240 23100 0 0 {name=Xn_1173}
N 3148 23070 3128 23070 {lab=n_0601}
C {./lab_pin.sym} 3128 23070 0 0 {name=l1232_0 lab=n_0601}
N 3148 23090 3128 23090 {lab=n_0607}
C {./lab_pin.sym} 3128 23090 0 0 {name=l1232_1 lab=n_0607}
N 3148 23110 3128 23110 {lab=n_0605}
C {./lab_pin.sym} 3128 23110 0 0 {name=l1232_2 lab=n_0605}
N 3148 23130 3128 23130 {lab=n_0608}
C {./lab_pin.sym} 3128 23130 0 0 {name=l1232_3 lab=n_0608}
N 3332 23070 3352 23070 {lab=VDD}
C {./lab_pin.sym} 3352 23070 0 1 {name=l1232_4 lab=VDD}
N 3332 23090 3352 23090 {lab=VDD}
C {./lab_pin.sym} 3352 23090 0 1 {name=l1232_5 lab=VDD}
N 3332 23110 3352 23110 {lab=VSS}
C {./lab_pin.sym} 3352 23110 0 1 {name=l1232_6 lab=VSS}
N 3332 23130 3352 23130 {lab=VSS}
C {./lab_pin.sym} 3352 23130 0 1 {name=l1232_7 lab=VSS}
C {./aoi21_1.sym} 3645 23100 0 0 {name=Xn_1174}
N 3553 23070 3533 23070 {lab=n_0602}
C {./lab_pin.sym} 3533 23070 0 0 {name=l1233_0 lab=n_0602}
N 3553 23090 3533 23090 {lab=n_0606}
C {./lab_pin.sym} 3533 23090 0 0 {name=l1233_1 lab=n_0606}
N 3553 23110 3533 23110 {lab=n_0604}
C {./lab_pin.sym} 3533 23110 0 0 {name=l1233_2 lab=n_0604}
N 3553 23130 3533 23130 {lab=n_0609}
C {./lab_pin.sym} 3533 23130 0 0 {name=l1233_3 lab=n_0609}
N 3737 23070 3757 23070 {lab=VDD}
C {./lab_pin.sym} 3757 23070 0 1 {name=l1233_4 lab=VDD}
N 3737 23090 3757 23090 {lab=VDD}
C {./lab_pin.sym} 3757 23090 0 1 {name=l1233_5 lab=VDD}
N 3737 23110 3757 23110 {lab=VSS}
C {./lab_pin.sym} 3757 23110 0 1 {name=l1233_6 lab=VSS}
N 3737 23130 3757 23130 {lab=VSS}
C {./lab_pin.sym} 3757 23130 0 1 {name=l1233_7 lab=VSS}
C {./nand2_1.sym} 4050 23100 0 0 {name=Xn_1175}
N 3958 23070 3938 23070 {lab=u_cas_int_out_int2_b4}
C {./lab_pin.sym} 3938 23070 0 0 {name=l1234_0 lab=u_cas_int_out_int2_b4}
N 3958 23090 3938 23090 {lab=out_cas_int_b4}
C {./lab_pin.sym} 3938 23090 0 0 {name=l1234_1 lab=out_cas_int_b4}
N 3958 23110 3938 23110 {lab=n_0610}
C {./lab_pin.sym} 3938 23110 0 0 {name=l1234_2 lab=n_0610}
N 3958 23130 3938 23130 {lab=VDD}
C {./lab_pin.sym} 3938 23130 0 0 {name=l1234_3 lab=VDD}
N 4142 23080 4162 23080 {lab=VDD}
C {./lab_pin.sym} 4162 23080 0 1 {name=l1234_4 lab=VDD}
N 4142 23100 4162 23100 {lab=VSS}
C {./lab_pin.sym} 4162 23100 0 1 {name=l1234_5 lab=VSS}
N 4142 23120 4162 23120 {lab=VSS}
C {./lab_pin.sym} 4162 23120 0 1 {name=l1234_6 lab=VSS}
C {./xor2_1.sym} 4455 23100 0 0 {name=Xn_1176}
N 4363 23070 4343 23070 {lab=u_cas_int_out_int2_b4}
C {./lab_pin.sym} 4343 23070 0 0 {name=l1235_0 lab=u_cas_int_out_int2_b4}
N 4363 23090 4343 23090 {lab=out_cas_int_b4}
C {./lab_pin.sym} 4343 23090 0 0 {name=l1235_1 lab=out_cas_int_b4}
N 4363 23110 4343 23110 {lab=n_0611}
C {./lab_pin.sym} 4343 23110 0 0 {name=l1235_2 lab=n_0611}
N 4363 23130 4343 23130 {lab=VDD}
C {./lab_pin.sym} 4343 23130 0 0 {name=l1235_3 lab=VDD}
N 4547 23080 4567 23080 {lab=VDD}
C {./lab_pin.sym} 4567 23080 0 1 {name=l1235_4 lab=VDD}
N 4547 23100 4567 23100 {lab=VSS}
C {./lab_pin.sym} 4567 23100 0 1 {name=l1235_5 lab=VSS}
N 4547 23120 4567 23120 {lab=VSS}
C {./lab_pin.sym} 4567 23120 0 1 {name=l1235_6 lab=VSS}
C {./nand2_1.sym} 0 23325 0 0 {name=Xn_1177}
N -92 23295 -112 23295 {lab=n_0609}
C {./lab_pin.sym} -112 23295 0 0 {name=l1236_0 lab=n_0609}
N -92 23315 -112 23315 {lab=n_0611}
C {./lab_pin.sym} -112 23315 0 0 {name=l1236_1 lab=n_0611}
N -92 23335 -112 23335 {lab=n_0612}
C {./lab_pin.sym} -112 23335 0 0 {name=l1236_2 lab=n_0612}
N -92 23355 -112 23355 {lab=VDD}
C {./lab_pin.sym} -112 23355 0 0 {name=l1236_3 lab=VDD}
N 92 23305 112 23305 {lab=VDD}
C {./lab_pin.sym} 112 23305 0 1 {name=l1236_4 lab=VDD}
N 92 23325 112 23325 {lab=VSS}
C {./lab_pin.sym} 112 23325 0 1 {name=l1236_5 lab=VSS}
N 92 23345 112 23345 {lab=VSS}
C {./lab_pin.sym} 112 23345 0 1 {name=l1236_6 lab=VSS}
C {./xor2_1.sym} 405 23325 0 0 {name=Xn_1178}
N 313 23295 293 23295 {lab=n_0609}
C {./lab_pin.sym} 293 23295 0 0 {name=l1237_0 lab=n_0609}
N 313 23315 293 23315 {lab=n_0611}
C {./lab_pin.sym} 293 23315 0 0 {name=l1237_1 lab=n_0611}
N 313 23335 293 23335 {lab=n_0131}
C {./lab_pin.sym} 293 23335 0 0 {name=l1237_2 lab=n_0131}
N 313 23355 293 23355 {lab=VDD}
C {./lab_pin.sym} 293 23355 0 0 {name=l1237_3 lab=VDD}
N 497 23305 517 23305 {lab=VDD}
C {./lab_pin.sym} 517 23305 0 1 {name=l1237_4 lab=VDD}
N 497 23325 517 23325 {lab=VSS}
C {./lab_pin.sym} 517 23325 0 1 {name=l1237_5 lab=VSS}
N 497 23345 517 23345 {lab=VSS}
C {./lab_pin.sym} 517 23345 0 1 {name=l1237_6 lab=VSS}
C {./nand2_1.sym} 810 23325 0 0 {name=Xn_1179}
N 718 23295 698 23295 {lab=n_0610}
C {./lab_pin.sym} 698 23295 0 0 {name=l1238_0 lab=n_0610}
N 718 23315 698 23315 {lab=n_0612}
C {./lab_pin.sym} 698 23315 0 0 {name=l1238_1 lab=n_0612}
N 718 23335 698 23335 {lab=n_0613}
C {./lab_pin.sym} 698 23335 0 0 {name=l1238_2 lab=n_0613}
N 718 23355 698 23355 {lab=VDD}
C {./lab_pin.sym} 698 23355 0 0 {name=l1238_3 lab=VDD}
N 902 23305 922 23305 {lab=VDD}
C {./lab_pin.sym} 922 23305 0 1 {name=l1238_4 lab=VDD}
N 902 23325 922 23325 {lab=VSS}
C {./lab_pin.sym} 922 23325 0 1 {name=l1238_5 lab=VSS}
N 902 23345 922 23345 {lab=VSS}
C {./lab_pin.sym} 922 23345 0 1 {name=l1238_6 lab=VSS}
C {./nor2_1.sym} 1215 23325 0 0 {name=Xn_1180}
N 1123 23295 1103 23295 {lab=u_cas_int_out_int2_b5}
C {./lab_pin.sym} 1103 23295 0 0 {name=l1239_0 lab=u_cas_int_out_int2_b5}
N 1123 23315 1103 23315 {lab=out_cas_int_b5}
C {./lab_pin.sym} 1103 23315 0 0 {name=l1239_1 lab=out_cas_int_b5}
N 1123 23335 1103 23335 {lab=n_0614}
C {./lab_pin.sym} 1103 23335 0 0 {name=l1239_2 lab=n_0614}
N 1123 23355 1103 23355 {lab=VDD}
C {./lab_pin.sym} 1103 23355 0 0 {name=l1239_3 lab=VDD}
N 1307 23305 1327 23305 {lab=VDD}
C {./lab_pin.sym} 1327 23305 0 1 {name=l1239_4 lab=VDD}
N 1307 23325 1327 23325 {lab=VSS}
C {./lab_pin.sym} 1327 23325 0 1 {name=l1239_5 lab=VSS}
N 1307 23345 1327 23345 {lab=VSS}
C {./lab_pin.sym} 1327 23345 0 1 {name=l1239_6 lab=VSS}
C {./xor2_1.sym} 1620 23325 0 0 {name=Xn_1181}
N 1528 23295 1508 23295 {lab=u_cas_int_out_int2_b5}
C {./lab_pin.sym} 1508 23295 0 0 {name=l1240_0 lab=u_cas_int_out_int2_b5}
N 1528 23315 1508 23315 {lab=out_cas_int_b5}
C {./lab_pin.sym} 1508 23315 0 0 {name=l1240_1 lab=out_cas_int_b5}
N 1528 23335 1508 23335 {lab=n_0615}
C {./lab_pin.sym} 1508 23335 0 0 {name=l1240_2 lab=n_0615}
N 1528 23355 1508 23355 {lab=VDD}
C {./lab_pin.sym} 1508 23355 0 0 {name=l1240_3 lab=VDD}
N 1712 23305 1732 23305 {lab=VDD}
C {./lab_pin.sym} 1732 23305 0 1 {name=l1240_4 lab=VDD}
N 1712 23325 1732 23325 {lab=VSS}
C {./lab_pin.sym} 1732 23325 0 1 {name=l1240_5 lab=VSS}
N 1712 23345 1732 23345 {lab=VSS}
C {./lab_pin.sym} 1732 23345 0 1 {name=l1240_6 lab=VSS}
C {./xor2_1.sym} 2025 23325 0 0 {name=Xn_1182}
N 1933 23295 1913 23295 {lab=n_0613}
C {./lab_pin.sym} 1913 23295 0 0 {name=l1241_0 lab=n_0613}
N 1933 23315 1913 23315 {lab=n_0615}
C {./lab_pin.sym} 1913 23315 0 0 {name=l1241_1 lab=n_0615}
N 1933 23335 1913 23335 {lab=n_0132}
C {./lab_pin.sym} 1913 23335 0 0 {name=l1241_2 lab=n_0132}
N 1933 23355 1913 23355 {lab=VDD}
C {./lab_pin.sym} 1913 23355 0 0 {name=l1241_3 lab=VDD}
N 2117 23305 2137 23305 {lab=VDD}
C {./lab_pin.sym} 2137 23305 0 1 {name=l1241_4 lab=VDD}
N 2117 23325 2137 23325 {lab=VSS}
C {./lab_pin.sym} 2137 23325 0 1 {name=l1241_5 lab=VSS}
N 2117 23345 2137 23345 {lab=VSS}
C {./lab_pin.sym} 2137 23345 0 1 {name=l1241_6 lab=VSS}
C {./aoi22_1.sym} 2430 23325 0 0 {name=Xn_1183}
N 2338 23285 2318 23285 {lab=u_cas_int_out_int2_b4}
C {./lab_pin.sym} 2318 23285 0 0 {name=l1242_0 lab=u_cas_int_out_int2_b4}
N 2338 23305 2318 23305 {lab=out_cas_int_b4}
C {./lab_pin.sym} 2318 23305 0 0 {name=l1242_1 lab=out_cas_int_b4}
N 2338 23325 2318 23325 {lab=u_cas_int_out_int2_b5}
C {./lab_pin.sym} 2318 23325 0 0 {name=l1242_2 lab=u_cas_int_out_int2_b5}
N 2338 23345 2318 23345 {lab=out_cas_int_b5}
C {./lab_pin.sym} 2318 23345 0 0 {name=l1242_3 lab=out_cas_int_b5}
N 2338 23365 2318 23365 {lab=n_0616}
C {./lab_pin.sym} 2318 23365 0 0 {name=l1242_4 lab=n_0616}
N 2522 23295 2542 23295 {lab=VDD}
C {./lab_pin.sym} 2542 23295 0 1 {name=l1242_5 lab=VDD}
N 2522 23315 2542 23315 {lab=VDD}
C {./lab_pin.sym} 2542 23315 0 1 {name=l1242_6 lab=VDD}
N 2522 23335 2542 23335 {lab=VSS}
C {./lab_pin.sym} 2542 23335 0 1 {name=l1242_7 lab=VSS}
N 2522 23355 2542 23355 {lab=VSS}
C {./lab_pin.sym} 2542 23355 0 1 {name=l1242_8 lab=VSS}
C {./aoi21_1.sym} 2835 23325 0 0 {name=Xn_1184}
N 2743 23295 2723 23295 {lab=n_0612}
C {./lab_pin.sym} 2723 23295 0 0 {name=l1243_0 lab=n_0612}
N 2743 23315 2723 23315 {lab=n_0616}
C {./lab_pin.sym} 2723 23315 0 0 {name=l1243_1 lab=n_0616}
N 2743 23335 2723 23335 {lab=n_0614}
C {./lab_pin.sym} 2723 23335 0 0 {name=l1243_2 lab=n_0614}
N 2743 23355 2723 23355 {lab=n_0617}
C {./lab_pin.sym} 2723 23355 0 0 {name=l1243_3 lab=n_0617}
N 2927 23295 2947 23295 {lab=VDD}
C {./lab_pin.sym} 2947 23295 0 1 {name=l1243_4 lab=VDD}
N 2927 23315 2947 23315 {lab=VDD}
C {./lab_pin.sym} 2947 23315 0 1 {name=l1243_5 lab=VDD}
N 2927 23335 2947 23335 {lab=VSS}
C {./lab_pin.sym} 2947 23335 0 1 {name=l1243_6 lab=VSS}
N 2927 23355 2947 23355 {lab=VSS}
C {./lab_pin.sym} 2947 23355 0 1 {name=l1243_7 lab=VSS}
C {./or2_1.sym} 3240 23325 0 0 {name=Xn_1185}
N 3148 23295 3128 23295 {lab=u_cas_int_out_int2_b6}
C {./lab_pin.sym} 3128 23295 0 0 {name=l1244_0 lab=u_cas_int_out_int2_b6}
N 3148 23315 3128 23315 {lab=out_cas_int_b6}
C {./lab_pin.sym} 3128 23315 0 0 {name=l1244_1 lab=out_cas_int_b6}
N 3148 23335 3128 23335 {lab=n_0618}
C {./lab_pin.sym} 3128 23335 0 0 {name=l1244_2 lab=n_0618}
N 3148 23355 3128 23355 {lab=VDD}
C {./lab_pin.sym} 3128 23355 0 0 {name=l1244_3 lab=VDD}
N 3332 23305 3352 23305 {lab=VDD}
C {./lab_pin.sym} 3352 23305 0 1 {name=l1244_4 lab=VDD}
N 3332 23325 3352 23325 {lab=VSS}
C {./lab_pin.sym} 3352 23325 0 1 {name=l1244_5 lab=VSS}
N 3332 23345 3352 23345 {lab=VSS}
C {./lab_pin.sym} 3352 23345 0 1 {name=l1244_6 lab=VSS}
C {./nand2_1.sym} 3645 23325 0 0 {name=Xn_1186}
N 3553 23295 3533 23295 {lab=u_cas_int_out_int2_b6}
C {./lab_pin.sym} 3533 23295 0 0 {name=l1245_0 lab=u_cas_int_out_int2_b6}
N 3553 23315 3533 23315 {lab=out_cas_int_b6}
C {./lab_pin.sym} 3533 23315 0 0 {name=l1245_1 lab=out_cas_int_b6}
N 3553 23335 3533 23335 {lab=n_0619}
C {./lab_pin.sym} 3533 23335 0 0 {name=l1245_2 lab=n_0619}
N 3553 23355 3533 23355 {lab=VDD}
C {./lab_pin.sym} 3533 23355 0 0 {name=l1245_3 lab=VDD}
N 3737 23305 3757 23305 {lab=VDD}
C {./lab_pin.sym} 3757 23305 0 1 {name=l1245_4 lab=VDD}
N 3737 23325 3757 23325 {lab=VSS}
C {./lab_pin.sym} 3757 23325 0 1 {name=l1245_5 lab=VSS}
N 3737 23345 3757 23345 {lab=VSS}
C {./lab_pin.sym} 3757 23345 0 1 {name=l1245_6 lab=VSS}
C {./and2_1.sym} 4050 23325 0 0 {name=Xn_1187}
N 3958 23295 3938 23295 {lab=n_0618}
C {./lab_pin.sym} 3938 23295 0 0 {name=l1246_0 lab=n_0618}
N 3958 23315 3938 23315 {lab=n_0619}
C {./lab_pin.sym} 3938 23315 0 0 {name=l1246_1 lab=n_0619}
N 3958 23335 3938 23335 {lab=n_0620}
C {./lab_pin.sym} 3938 23335 0 0 {name=l1246_2 lab=n_0620}
N 3958 23355 3938 23355 {lab=VDD}
C {./lab_pin.sym} 3938 23355 0 0 {name=l1246_3 lab=VDD}
N 4142 23305 4162 23305 {lab=VDD}
C {./lab_pin.sym} 4162 23305 0 1 {name=l1246_4 lab=VDD}
N 4142 23325 4162 23325 {lab=VSS}
C {./lab_pin.sym} 4162 23325 0 1 {name=l1246_5 lab=VSS}
N 4142 23345 4162 23345 {lab=VSS}
C {./lab_pin.sym} 4162 23345 0 1 {name=l1246_6 lab=VSS}
C {./nand3_1.sym} 4455 23325 0 0 {name=Xn_1188}
N 4363 23295 4343 23295 {lab=n_0617}
C {./lab_pin.sym} 4343 23295 0 0 {name=l1247_0 lab=n_0617}
N 4363 23315 4343 23315 {lab=n_0618}
C {./lab_pin.sym} 4343 23315 0 0 {name=l1247_1 lab=n_0618}
N 4363 23335 4343 23335 {lab=n_0619}
C {./lab_pin.sym} 4343 23335 0 0 {name=l1247_2 lab=n_0619}
N 4363 23355 4343 23355 {lab=n_0621}
C {./lab_pin.sym} 4343 23355 0 0 {name=l1247_3 lab=n_0621}
N 4547 23295 4567 23295 {lab=VDD}
C {./lab_pin.sym} 4567 23295 0 1 {name=l1247_4 lab=VDD}
N 4547 23315 4567 23315 {lab=VDD}
C {./lab_pin.sym} 4567 23315 0 1 {name=l1247_5 lab=VDD}
N 4547 23335 4567 23335 {lab=VSS}
C {./lab_pin.sym} 4567 23335 0 1 {name=l1247_6 lab=VSS}
N 4547 23355 4567 23355 {lab=VSS}
C {./lab_pin.sym} 4567 23355 0 1 {name=l1247_7 lab=VSS}
C {./xor2_1.sym} 0 23550 0 0 {name=Xn_1189}
N -92 23520 -112 23520 {lab=n_0617}
C {./lab_pin.sym} -112 23520 0 0 {name=l1248_0 lab=n_0617}
N -92 23540 -112 23540 {lab=n_0620}
C {./lab_pin.sym} -112 23540 0 0 {name=l1248_1 lab=n_0620}
N -92 23560 -112 23560 {lab=n_0133}
C {./lab_pin.sym} -112 23560 0 0 {name=l1248_2 lab=n_0133}
N -92 23580 -112 23580 {lab=VDD}
C {./lab_pin.sym} -112 23580 0 0 {name=l1248_3 lab=VDD}
N 92 23530 112 23530 {lab=VDD}
C {./lab_pin.sym} 112 23530 0 1 {name=l1248_4 lab=VDD}
N 92 23550 112 23550 {lab=VSS}
C {./lab_pin.sym} 112 23550 0 1 {name=l1248_5 lab=VSS}
N 92 23570 112 23570 {lab=VSS}
C {./lab_pin.sym} 112 23570 0 1 {name=l1248_6 lab=VSS}
C {./or2_1.sym} 405 23550 0 0 {name=Xn_1190}
N 313 23520 293 23520 {lab=u_cas_int_out_int2_b7}
C {./lab_pin.sym} 293 23520 0 0 {name=l1249_0 lab=u_cas_int_out_int2_b7}
N 313 23540 293 23540 {lab=out_cas_int_b7}
C {./lab_pin.sym} 293 23540 0 0 {name=l1249_1 lab=out_cas_int_b7}
N 313 23560 293 23560 {lab=n_0622}
C {./lab_pin.sym} 293 23560 0 0 {name=l1249_2 lab=n_0622}
N 313 23580 293 23580 {lab=VDD}
C {./lab_pin.sym} 293 23580 0 0 {name=l1249_3 lab=VDD}
N 497 23530 517 23530 {lab=VDD}
C {./lab_pin.sym} 517 23530 0 1 {name=l1249_4 lab=VDD}
N 497 23550 517 23550 {lab=VSS}
C {./lab_pin.sym} 517 23550 0 1 {name=l1249_5 lab=VSS}
N 497 23570 517 23570 {lab=VSS}
C {./lab_pin.sym} 517 23570 0 1 {name=l1249_6 lab=VSS}
C {./nand2_1.sym} 810 23550 0 0 {name=Xn_1191}
N 718 23520 698 23520 {lab=u_cas_int_out_int2_b7}
C {./lab_pin.sym} 698 23520 0 0 {name=l1250_0 lab=u_cas_int_out_int2_b7}
N 718 23540 698 23540 {lab=out_cas_int_b7}
C {./lab_pin.sym} 698 23540 0 0 {name=l1250_1 lab=out_cas_int_b7}
N 718 23560 698 23560 {lab=n_0623}
C {./lab_pin.sym} 698 23560 0 0 {name=l1250_2 lab=n_0623}
N 718 23580 698 23580 {lab=VDD}
C {./lab_pin.sym} 698 23580 0 0 {name=l1250_3 lab=VDD}
N 902 23530 922 23530 {lab=VDD}
C {./lab_pin.sym} 922 23530 0 1 {name=l1250_4 lab=VDD}
N 902 23550 922 23550 {lab=VSS}
C {./lab_pin.sym} 922 23550 0 1 {name=l1250_5 lab=VSS}
N 902 23570 922 23570 {lab=VSS}
C {./lab_pin.sym} 922 23570 0 1 {name=l1250_6 lab=VSS}
C {./xor2_1.sym} 1215 23550 0 0 {name=Xn_1192}
N 1123 23520 1103 23520 {lab=u_cas_int_out_int2_b7}
C {./lab_pin.sym} 1103 23520 0 0 {name=l1251_0 lab=u_cas_int_out_int2_b7}
N 1123 23540 1103 23540 {lab=out_cas_int_b7}
C {./lab_pin.sym} 1103 23540 0 0 {name=l1251_1 lab=out_cas_int_b7}
N 1123 23560 1103 23560 {lab=n_0624}
C {./lab_pin.sym} 1103 23560 0 0 {name=l1251_2 lab=n_0624}
N 1123 23580 1103 23580 {lab=VDD}
C {./lab_pin.sym} 1103 23580 0 0 {name=l1251_3 lab=VDD}
N 1307 23530 1327 23530 {lab=VDD}
C {./lab_pin.sym} 1327 23530 0 1 {name=l1251_4 lab=VDD}
N 1307 23550 1327 23550 {lab=VSS}
C {./lab_pin.sym} 1327 23550 0 1 {name=l1251_5 lab=VSS}
N 1307 23570 1327 23570 {lab=VSS}
C {./lab_pin.sym} 1327 23570 0 1 {name=l1251_6 lab=VSS}
C {./and4_1.sym} 1620 23550 0 0 {name=Xn_1193}
N 1528 23510 1508 23510 {lab=n_0619}
C {./lab_pin.sym} 1508 23510 0 0 {name=l1252_0 lab=n_0619}
N 1528 23530 1508 23530 {lab=n_0621}
C {./lab_pin.sym} 1508 23530 0 0 {name=l1252_1 lab=n_0621}
N 1528 23550 1508 23550 {lab=n_0622}
C {./lab_pin.sym} 1508 23550 0 0 {name=l1252_2 lab=n_0622}
N 1528 23570 1508 23570 {lab=n_0623}
C {./lab_pin.sym} 1508 23570 0 0 {name=l1252_3 lab=n_0623}
N 1528 23590 1508 23590 {lab=n_0625}
C {./lab_pin.sym} 1508 23590 0 0 {name=l1252_4 lab=n_0625}
N 1712 23520 1732 23520 {lab=VDD}
C {./lab_pin.sym} 1732 23520 0 1 {name=l1252_5 lab=VDD}
N 1712 23540 1732 23540 {lab=VDD}
C {./lab_pin.sym} 1732 23540 0 1 {name=l1252_6 lab=VDD}
N 1712 23560 1732 23560 {lab=VSS}
C {./lab_pin.sym} 1732 23560 0 1 {name=l1252_7 lab=VSS}
N 1712 23580 1732 23580 {lab=VSS}
C {./lab_pin.sym} 1732 23580 0 1 {name=l1252_8 lab=VSS}
C {./aoi22_1.sym} 2025 23550 0 0 {name=Xn_1194}
N 1933 23510 1913 23510 {lab=n_0619}
C {./lab_pin.sym} 1913 23510 0 0 {name=l1253_0 lab=n_0619}
N 1933 23530 1913 23530 {lab=n_0621}
C {./lab_pin.sym} 1913 23530 0 0 {name=l1253_1 lab=n_0621}
N 1933 23550 1913 23550 {lab=n_0622}
C {./lab_pin.sym} 1913 23550 0 0 {name=l1253_2 lab=n_0622}
N 1933 23570 1913 23570 {lab=n_0623}
C {./lab_pin.sym} 1913 23570 0 0 {name=l1253_3 lab=n_0623}
N 1933 23590 1913 23590 {lab=n_0626}
C {./lab_pin.sym} 1913 23590 0 0 {name=l1253_4 lab=n_0626}
N 2117 23520 2137 23520 {lab=VDD}
C {./lab_pin.sym} 2137 23520 0 1 {name=l1253_5 lab=VDD}
N 2117 23540 2137 23540 {lab=VDD}
C {./lab_pin.sym} 2137 23540 0 1 {name=l1253_6 lab=VDD}
N 2117 23560 2137 23560 {lab=VSS}
C {./lab_pin.sym} 2137 23560 0 1 {name=l1253_7 lab=VSS}
N 2117 23580 2137 23580 {lab=VSS}
C {./lab_pin.sym} 2137 23580 0 1 {name=l1253_8 lab=VSS}
C {./or2_1.sym} 2430 23550 0 0 {name=Xn_1195}
N 2338 23520 2318 23520 {lab=n_0625}
C {./lab_pin.sym} 2318 23520 0 0 {name=l1254_0 lab=n_0625}
N 2338 23540 2318 23540 {lab=n_0626}
C {./lab_pin.sym} 2318 23540 0 0 {name=l1254_1 lab=n_0626}
N 2338 23560 2318 23560 {lab=n_0134}
C {./lab_pin.sym} 2318 23560 0 0 {name=l1254_2 lab=n_0134}
N 2338 23580 2318 23580 {lab=VDD}
C {./lab_pin.sym} 2318 23580 0 0 {name=l1254_3 lab=VDD}
N 2522 23530 2542 23530 {lab=VDD}
C {./lab_pin.sym} 2542 23530 0 1 {name=l1254_4 lab=VDD}
N 2522 23550 2542 23550 {lab=VSS}
C {./lab_pin.sym} 2542 23550 0 1 {name=l1254_5 lab=VSS}
N 2522 23570 2542 23570 {lab=VSS}
C {./lab_pin.sym} 2542 23570 0 1 {name=l1254_6 lab=VSS}
C {./nand4_1.sym} 2835 23550 0 0 {name=Xn_1196}
N 2743 23510 2723 23510 {lab=n_0618}
C {./lab_pin.sym} 2723 23510 0 0 {name=l1255_0 lab=n_0618}
N 2743 23530 2723 23530 {lab=n_0619}
C {./lab_pin.sym} 2723 23530 0 0 {name=l1255_1 lab=n_0619}
N 2743 23550 2723 23550 {lab=n_0622}
C {./lab_pin.sym} 2723 23550 0 0 {name=l1255_2 lab=n_0622}
N 2743 23570 2723 23570 {lab=n_0623}
C {./lab_pin.sym} 2723 23570 0 0 {name=l1255_3 lab=n_0623}
N 2743 23590 2723 23590 {lab=n_0627}
C {./lab_pin.sym} 2723 23590 0 0 {name=l1255_4 lab=n_0627}
N 2927 23520 2947 23520 {lab=VDD}
C {./lab_pin.sym} 2947 23520 0 1 {name=l1255_5 lab=VDD}
N 2927 23540 2947 23540 {lab=VDD}
C {./lab_pin.sym} 2947 23540 0 1 {name=l1255_6 lab=VDD}
N 2927 23560 2947 23560 {lab=VSS}
C {./lab_pin.sym} 2947 23560 0 1 {name=l1255_7 lab=VSS}
N 2927 23580 2947 23580 {lab=VSS}
C {./lab_pin.sym} 2947 23580 0 1 {name=l1255_8 lab=VSS}
C {./and4_1.sym} 3240 23550 0 0 {name=Xn_1197}
N 3148 23510 3128 23510 {lab=n_0611}
C {./lab_pin.sym} 3128 23510 0 0 {name=l1256_0 lab=n_0611}
N 3148 23530 3128 23530 {lab=n_0615}
C {./lab_pin.sym} 3128 23530 0 0 {name=l1256_1 lab=n_0615}
N 3148 23550 3128 23550 {lab=n_0620}
C {./lab_pin.sym} 3128 23550 0 0 {name=l1256_2 lab=n_0620}
N 3148 23570 3128 23570 {lab=n_0624}
C {./lab_pin.sym} 3128 23570 0 0 {name=l1256_3 lab=n_0624}
N 3148 23590 3128 23590 {lab=n_0628}
C {./lab_pin.sym} 3128 23590 0 0 {name=l1256_4 lab=n_0628}
N 3332 23520 3352 23520 {lab=VDD}
C {./lab_pin.sym} 3352 23520 0 1 {name=l1256_5 lab=VDD}
N 3332 23540 3352 23540 {lab=VDD}
C {./lab_pin.sym} 3352 23540 0 1 {name=l1256_6 lab=VDD}
N 3332 23560 3352 23560 {lab=VSS}
C {./lab_pin.sym} 3352 23560 0 1 {name=l1256_7 lab=VSS}
N 3332 23580 3352 23580 {lab=VSS}
C {./lab_pin.sym} 3352 23580 0 1 {name=l1256_8 lab=VSS}
C {./nand4_1.sym} 3645 23550 0 0 {name=Xn_1198}
N 3553 23510 3533 23510 {lab=n_0611}
C {./lab_pin.sym} 3533 23510 0 0 {name=l1257_0 lab=n_0611}
N 3553 23530 3533 23530 {lab=n_0615}
C {./lab_pin.sym} 3533 23530 0 0 {name=l1257_1 lab=n_0615}
N 3553 23550 3533 23550 {lab=n_0620}
C {./lab_pin.sym} 3533 23550 0 0 {name=l1257_2 lab=n_0620}
N 3553 23570 3533 23570 {lab=n_0624}
C {./lab_pin.sym} 3533 23570 0 0 {name=l1257_3 lab=n_0624}
N 3553 23590 3533 23590 {lab=n_0629}
C {./lab_pin.sym} 3533 23590 0 0 {name=l1257_4 lab=n_0629}
N 3737 23520 3757 23520 {lab=VDD}
C {./lab_pin.sym} 3757 23520 0 1 {name=l1257_5 lab=VDD}
N 3737 23540 3757 23540 {lab=VDD}
C {./lab_pin.sym} 3757 23540 0 1 {name=l1257_6 lab=VDD}
N 3737 23560 3757 23560 {lab=VSS}
C {./lab_pin.sym} 3757 23560 0 1 {name=l1257_7 lab=VSS}
N 3737 23580 3757 23580 {lab=VSS}
C {./lab_pin.sym} 3757 23580 0 1 {name=l1257_8 lab=VSS}
C {./or2_1.sym} 4050 23550 0 0 {name=Xn_1199}
N 3958 23520 3938 23520 {lab=n_0614}
C {./lab_pin.sym} 3938 23520 0 0 {name=l1258_0 lab=n_0614}
N 3958 23540 3938 23540 {lab=n_0616}
C {./lab_pin.sym} 3938 23540 0 0 {name=l1258_1 lab=n_0616}
N 3958 23560 3938 23560 {lab=n_0630}
C {./lab_pin.sym} 3938 23560 0 0 {name=l1258_2 lab=n_0630}
N 3958 23580 3938 23580 {lab=VDD}
C {./lab_pin.sym} 3938 23580 0 0 {name=l1258_3 lab=VDD}
N 4142 23530 4162 23530 {lab=VDD}
C {./lab_pin.sym} 4162 23530 0 1 {name=l1258_4 lab=VDD}
N 4142 23550 4162 23550 {lab=VSS}
C {./lab_pin.sym} 4162 23550 0 1 {name=l1258_5 lab=VSS}
N 4142 23570 4162 23570 {lab=VSS}
C {./lab_pin.sym} 4162 23570 0 1 {name=l1258_6 lab=VSS}
C {./or2_1.sym} 4455 23550 0 0 {name=Xn_1200}
N 4363 23520 4343 23520 {lab=n_0627}
C {./lab_pin.sym} 4343 23520 0 0 {name=l1259_0 lab=n_0627}
N 4363 23540 4343 23540 {lab=n_0630}
C {./lab_pin.sym} 4343 23540 0 0 {name=l1259_1 lab=n_0630}
N 4363 23560 4343 23560 {lab=n_0631}
C {./lab_pin.sym} 4343 23560 0 0 {name=l1259_2 lab=n_0631}
N 4363 23580 4343 23580 {lab=VDD}
C {./lab_pin.sym} 4343 23580 0 0 {name=l1259_3 lab=VDD}
N 4547 23530 4567 23530 {lab=VDD}
C {./lab_pin.sym} 4567 23530 0 1 {name=l1259_4 lab=VDD}
N 4547 23550 4567 23550 {lab=VSS}
C {./lab_pin.sym} 4567 23550 0 1 {name=l1259_5 lab=VSS}
N 4547 23570 4567 23570 {lab=VSS}
C {./lab_pin.sym} 4567 23570 0 1 {name=l1259_6 lab=VSS}
C {./nand2_1.sym} 0 23775 0 0 {name=Xn_1201}
N -92 23745 -112 23745 {lab=n_0619}
C {./lab_pin.sym} -112 23745 0 0 {name=l1260_0 lab=n_0619}
N -92 23765 -112 23765 {lab=n_0623}
C {./lab_pin.sym} -112 23765 0 0 {name=l1260_1 lab=n_0623}
N -92 23785 -112 23785 {lab=n_0632}
C {./lab_pin.sym} -112 23785 0 0 {name=l1260_2 lab=n_0632}
N -92 23805 -112 23805 {lab=VDD}
C {./lab_pin.sym} -112 23805 0 0 {name=l1260_3 lab=VDD}
N 92 23755 112 23755 {lab=VDD}
C {./lab_pin.sym} 112 23755 0 1 {name=l1260_4 lab=VDD}
N 92 23775 112 23775 {lab=VSS}
C {./lab_pin.sym} 112 23775 0 1 {name=l1260_5 lab=VSS}
N 92 23795 112 23795 {lab=VSS}
C {./lab_pin.sym} 112 23795 0 1 {name=l1260_6 lab=VSS}
C {./nand2_1.sym} 405 23775 0 0 {name=Xn_1202}
N 313 23745 293 23745 {lab=n_0622}
C {./lab_pin.sym} 293 23745 0 0 {name=l1261_0 lab=n_0622}
N 313 23765 293 23765 {lab=n_0632}
C {./lab_pin.sym} 293 23765 0 0 {name=l1261_1 lab=n_0632}
N 313 23785 293 23785 {lab=n_0633}
C {./lab_pin.sym} 293 23785 0 0 {name=l1261_2 lab=n_0633}
N 313 23805 293 23805 {lab=VDD}
C {./lab_pin.sym} 293 23805 0 0 {name=l1261_3 lab=VDD}
N 497 23755 517 23755 {lab=VDD}
C {./lab_pin.sym} 517 23755 0 1 {name=l1261_4 lab=VDD}
N 497 23775 517 23775 {lab=VSS}
C {./lab_pin.sym} 517 23775 0 1 {name=l1261_5 lab=VSS}
N 497 23795 517 23795 {lab=VSS}
C {./lab_pin.sym} 517 23795 0 1 {name=l1261_6 lab=VSS}
C {./oai21_1.sym} 810 23775 0 0 {name=Xn_1203}
N 718 23745 698 23745 {lab=n_0627}
C {./lab_pin.sym} 698 23745 0 0 {name=l1262_0 lab=n_0627}
N 718 23765 698 23765 {lab=n_0630}
C {./lab_pin.sym} 698 23765 0 0 {name=l1262_1 lab=n_0630}
N 718 23785 698 23785 {lab=n_0633}
C {./lab_pin.sym} 698 23785 0 0 {name=l1262_2 lab=n_0633}
N 718 23805 698 23805 {lab=n_0634}
C {./lab_pin.sym} 698 23805 0 0 {name=l1262_3 lab=n_0634}
N 902 23745 922 23745 {lab=VDD}
C {./lab_pin.sym} 922 23745 0 1 {name=l1262_4 lab=VDD}
N 902 23765 922 23765 {lab=VDD}
C {./lab_pin.sym} 922 23765 0 1 {name=l1262_5 lab=VDD}
N 902 23785 922 23785 {lab=VSS}
C {./lab_pin.sym} 922 23785 0 1 {name=l1262_6 lab=VSS}
N 902 23805 922 23805 {lab=VSS}
C {./lab_pin.sym} 922 23805 0 1 {name=l1262_7 lab=VSS}
C {./aoi21_1.sym} 1215 23775 0 0 {name=Xn_1204}
N 1123 23745 1103 23745 {lab=n_0609}
C {./lab_pin.sym} 1103 23745 0 0 {name=l1263_0 lab=n_0609}
N 1123 23765 1103 23765 {lab=n_0628}
C {./lab_pin.sym} 1103 23765 0 0 {name=l1263_1 lab=n_0628}
N 1123 23785 1103 23785 {lab=n_0634}
C {./lab_pin.sym} 1103 23785 0 0 {name=l1263_2 lab=n_0634}
N 1123 23805 1103 23805 {lab=n_0635}
C {./lab_pin.sym} 1103 23805 0 0 {name=l1263_3 lab=n_0635}
N 1307 23745 1327 23745 {lab=VDD}
C {./lab_pin.sym} 1327 23745 0 1 {name=l1263_4 lab=VDD}
N 1307 23765 1327 23765 {lab=VDD}
C {./lab_pin.sym} 1327 23765 0 1 {name=l1263_5 lab=VDD}
N 1307 23785 1327 23785 {lab=VSS}
C {./lab_pin.sym} 1327 23785 0 1 {name=l1263_6 lab=VSS}
N 1307 23805 1327 23805 {lab=VSS}
C {./lab_pin.sym} 1327 23805 0 1 {name=l1263_7 lab=VSS}
C {./oai211_1.sym} 1620 23775 0 0 {name=Xn_1205}
N 1528 23735 1508 23735 {lab=n_0608}
C {./lab_pin.sym} 1508 23735 0 0 {name=l1264_0 lab=n_0608}
N 1528 23755 1508 23755 {lab=n_0629}
C {./lab_pin.sym} 1508 23755 0 0 {name=l1264_1 lab=n_0629}
N 1528 23775 1508 23775 {lab=n_0631}
C {./lab_pin.sym} 1508 23775 0 0 {name=l1264_2 lab=n_0631}
N 1528 23795 1508 23795 {lab=n_0633}
C {./lab_pin.sym} 1508 23795 0 0 {name=l1264_3 lab=n_0633}
N 1528 23815 1508 23815 {lab=n_0636}
C {./lab_pin.sym} 1508 23815 0 0 {name=l1264_4 lab=n_0636}
N 1712 23745 1732 23745 {lab=VDD}
C {./lab_pin.sym} 1732 23745 0 1 {name=l1264_5 lab=VDD}
N 1712 23765 1732 23765 {lab=VDD}
C {./lab_pin.sym} 1732 23765 0 1 {name=l1264_6 lab=VDD}
N 1712 23785 1732 23785 {lab=VSS}
C {./lab_pin.sym} 1732 23785 0 1 {name=l1264_7 lab=VSS}
N 1712 23805 1732 23805 {lab=VSS}
C {./lab_pin.sym} 1732 23805 0 1 {name=l1264_8 lab=VSS}
C {./and2_1.sym} 2025 23775 0 0 {name=Xn_1206}
N 1933 23745 1913 23745 {lab=u_cas_int_out_int2_b8}
C {./lab_pin.sym} 1913 23745 0 0 {name=l1265_0 lab=u_cas_int_out_int2_b8}
N 1933 23765 1913 23765 {lab=out_cas_int_b8}
C {./lab_pin.sym} 1913 23765 0 0 {name=l1265_1 lab=out_cas_int_b8}
N 1933 23785 1913 23785 {lab=n_0637}
C {./lab_pin.sym} 1913 23785 0 0 {name=l1265_2 lab=n_0637}
N 1933 23805 1913 23805 {lab=VDD}
C {./lab_pin.sym} 1913 23805 0 0 {name=l1265_3 lab=VDD}
N 2117 23755 2137 23755 {lab=VDD}
C {./lab_pin.sym} 2137 23755 0 1 {name=l1265_4 lab=VDD}
N 2117 23775 2137 23775 {lab=VSS}
C {./lab_pin.sym} 2137 23775 0 1 {name=l1265_5 lab=VSS}
N 2117 23795 2137 23795 {lab=VSS}
C {./lab_pin.sym} 2137 23795 0 1 {name=l1265_6 lab=VSS}
C {./nor2_1.sym} 2430 23775 0 0 {name=Xn_1207}
N 2338 23745 2318 23745 {lab=u_cas_int_out_int2_b8}
C {./lab_pin.sym} 2318 23745 0 0 {name=l1266_0 lab=u_cas_int_out_int2_b8}
N 2338 23765 2318 23765 {lab=out_cas_int_b8}
C {./lab_pin.sym} 2318 23765 0 0 {name=l1266_1 lab=out_cas_int_b8}
N 2338 23785 2318 23785 {lab=n_0638}
C {./lab_pin.sym} 2318 23785 0 0 {name=l1266_2 lab=n_0638}
N 2338 23805 2318 23805 {lab=VDD}
C {./lab_pin.sym} 2318 23805 0 0 {name=l1266_3 lab=VDD}
N 2522 23755 2542 23755 {lab=VDD}
C {./lab_pin.sym} 2542 23755 0 1 {name=l1266_4 lab=VDD}
N 2522 23775 2542 23775 {lab=VSS}
C {./lab_pin.sym} 2542 23775 0 1 {name=l1266_5 lab=VSS}
N 2522 23795 2542 23795 {lab=VSS}
C {./lab_pin.sym} 2542 23795 0 1 {name=l1266_6 lab=VSS}
C {./nor2_1.sym} 2835 23775 0 0 {name=Xn_1208}
N 2743 23745 2723 23745 {lab=n_0637}
C {./lab_pin.sym} 2723 23745 0 0 {name=l1267_0 lab=n_0637}
N 2743 23765 2723 23765 {lab=n_0638}
C {./lab_pin.sym} 2723 23765 0 0 {name=l1267_1 lab=n_0638}
N 2743 23785 2723 23785 {lab=n_0639}
C {./lab_pin.sym} 2723 23785 0 0 {name=l1267_2 lab=n_0639}
N 2743 23805 2723 23805 {lab=VDD}
C {./lab_pin.sym} 2723 23805 0 0 {name=l1267_3 lab=VDD}
N 2927 23755 2947 23755 {lab=VDD}
C {./lab_pin.sym} 2947 23755 0 1 {name=l1267_4 lab=VDD}
N 2927 23775 2947 23775 {lab=VSS}
C {./lab_pin.sym} 2947 23775 0 1 {name=l1267_5 lab=VSS}
N 2927 23795 2947 23795 {lab=VSS}
C {./lab_pin.sym} 2947 23795 0 1 {name=l1267_6 lab=VSS}
C {./xor2_1.sym} 3240 23775 0 0 {name=Xn_1209}
N 3148 23745 3128 23745 {lab=n_0636}
C {./lab_pin.sym} 3128 23745 0 0 {name=l1268_0 lab=n_0636}
N 3148 23765 3128 23765 {lab=n_0639}
C {./lab_pin.sym} 3128 23765 0 0 {name=l1268_1 lab=n_0639}
N 3148 23785 3128 23785 {lab=n_0135}
C {./lab_pin.sym} 3128 23785 0 0 {name=l1268_2 lab=n_0135}
N 3148 23805 3128 23805 {lab=VDD}
C {./lab_pin.sym} 3128 23805 0 0 {name=l1268_3 lab=VDD}
N 3332 23755 3352 23755 {lab=VDD}
C {./lab_pin.sym} 3352 23755 0 1 {name=l1268_4 lab=VDD}
N 3332 23775 3352 23775 {lab=VSS}
C {./lab_pin.sym} 3352 23775 0 1 {name=l1268_5 lab=VSS}
N 3332 23795 3352 23795 {lab=VSS}
C {./lab_pin.sym} 3352 23795 0 1 {name=l1268_6 lab=VSS}
C {./aoi21_1.sym} 3645 23775 0 0 {name=Xn_1210}
N 3553 23745 3533 23745 {lab=n_0636}
C {./lab_pin.sym} 3533 23745 0 0 {name=l1269_0 lab=n_0636}
N 3553 23765 3533 23765 {lab=n_0639}
C {./lab_pin.sym} 3533 23765 0 0 {name=l1269_1 lab=n_0639}
N 3553 23785 3533 23785 {lab=n_0637}
C {./lab_pin.sym} 3533 23785 0 0 {name=l1269_2 lab=n_0637}
N 3553 23805 3533 23805 {lab=n_0640}
C {./lab_pin.sym} 3533 23805 0 0 {name=l1269_3 lab=n_0640}
N 3737 23745 3757 23745 {lab=VDD}
C {./lab_pin.sym} 3757 23745 0 1 {name=l1269_4 lab=VDD}
N 3737 23765 3757 23765 {lab=VDD}
C {./lab_pin.sym} 3757 23765 0 1 {name=l1269_5 lab=VDD}
N 3737 23785 3757 23785 {lab=VSS}
C {./lab_pin.sym} 3757 23785 0 1 {name=l1269_6 lab=VSS}
N 3737 23805 3757 23805 {lab=VSS}
C {./lab_pin.sym} 3757 23805 0 1 {name=l1269_7 lab=VSS}
C {./or2_1.sym} 4050 23775 0 0 {name=Xn_1211}
N 3958 23745 3938 23745 {lab=u_cas_int_out_int2_b9}
C {./lab_pin.sym} 3938 23745 0 0 {name=l1270_0 lab=u_cas_int_out_int2_b9}
N 3958 23765 3938 23765 {lab=out_cas_int_b9}
C {./lab_pin.sym} 3938 23765 0 0 {name=l1270_1 lab=out_cas_int_b9}
N 3958 23785 3938 23785 {lab=n_0641}
C {./lab_pin.sym} 3938 23785 0 0 {name=l1270_2 lab=n_0641}
N 3958 23805 3938 23805 {lab=VDD}
C {./lab_pin.sym} 3938 23805 0 0 {name=l1270_3 lab=VDD}
N 4142 23755 4162 23755 {lab=VDD}
C {./lab_pin.sym} 4162 23755 0 1 {name=l1270_4 lab=VDD}
N 4142 23775 4162 23775 {lab=VSS}
C {./lab_pin.sym} 4162 23775 0 1 {name=l1270_5 lab=VSS}
N 4142 23795 4162 23795 {lab=VSS}
C {./lab_pin.sym} 4162 23795 0 1 {name=l1270_6 lab=VSS}
C {./nand2_1.sym} 4455 23775 0 0 {name=Xn_1212}
N 4363 23745 4343 23745 {lab=u_cas_int_out_int2_b9}
C {./lab_pin.sym} 4343 23745 0 0 {name=l1271_0 lab=u_cas_int_out_int2_b9}
N 4363 23765 4343 23765 {lab=out_cas_int_b9}
C {./lab_pin.sym} 4343 23765 0 0 {name=l1271_1 lab=out_cas_int_b9}
N 4363 23785 4343 23785 {lab=n_0642}
C {./lab_pin.sym} 4343 23785 0 0 {name=l1271_2 lab=n_0642}
N 4363 23805 4343 23805 {lab=VDD}
C {./lab_pin.sym} 4343 23805 0 0 {name=l1271_3 lab=VDD}
N 4547 23755 4567 23755 {lab=VDD}
C {./lab_pin.sym} 4567 23755 0 1 {name=l1271_4 lab=VDD}
N 4547 23775 4567 23775 {lab=VSS}
C {./lab_pin.sym} 4567 23775 0 1 {name=l1271_5 lab=VSS}
N 4547 23795 4567 23795 {lab=VSS}
C {./lab_pin.sym} 4567 23795 0 1 {name=l1271_6 lab=VSS}
C {./xor3_1.sym} 0 24000 0 0 {name=Xn_1213}
N -92 23970 -112 23970 {lab=u_cas_int_out_int2_b9}
C {./lab_pin.sym} -112 23970 0 0 {name=l1272_0 lab=u_cas_int_out_int2_b9}
N -92 23990 -112 23990 {lab=n_0487}
C {./lab_pin.sym} -112 23990 0 0 {name=l1272_1 lab=n_0487}
N -92 24010 -112 24010 {lab=n_0640}
C {./lab_pin.sym} -112 24010 0 0 {name=l1272_2 lab=n_0640}
N -92 24030 -112 24030 {lab=n_0136}
C {./lab_pin.sym} -112 24030 0 0 {name=l1272_3 lab=n_0136}
N 92 23970 112 23970 {lab=VDD}
C {./lab_pin.sym} 112 23970 0 1 {name=l1272_4 lab=VDD}
N 92 23990 112 23990 {lab=VDD}
C {./lab_pin.sym} 112 23990 0 1 {name=l1272_5 lab=VDD}
N 92 24010 112 24010 {lab=VSS}
C {./lab_pin.sym} 112 24010 0 1 {name=l1272_6 lab=VSS}
N 92 24030 112 24030 {lab=VSS}
C {./lab_pin.sym} 112 24030 0 1 {name=l1272_7 lab=VSS}
C {./and3_1.sym} 405 24000 0 0 {name=Xn_1214}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__and3_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -50 72 -50 {}
L 4 72 -50 72 50 {}
L 4 72 50 -72 50 {}
L 4 -72 50 -72 -50 {}
T {@name} -72 -70 0 0 0.33 0.33 {}
T {and3_1} -68 39 0 0 0.2 0.2 {}
L 4 -92 -30 -72 -30 {}
T {A1} -66 -35 0 0 0.16 0.16 {}
L 4 -92 -10 -72 -10 {}
T {A2} -66 -15 0 0 0.16 0.16 {}
L 4 -92 10 -72 10 {}
T {A3} -66 5 0 0 0.16 0.16 {}
L 4 -92 30 -72 30 {}
T {Z} -66 25 0 0 0.16 0.16 {}
L 4 92 -30 72 -30 {}
T {VDD} 50.2 -35 0 0 0.16 0.16 {}
L 4 92 -10 72 -10 {}
T {VNW} 50.2 -15 0 0 0.16 0.16 {}
L 4 92 10 72 10 {}
T {VPW} 50.2 5 0 0 0.16 0.16 {}
L 4 92 30 72 30 {}
T {VSS} 50.2 25 0 0 0.16 0.16 {}
B 5 -94 -32 -90 -28 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -12 -90 -8 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 8 -90 12 {name=A3 dir=inout sim_pinnumber=3}
B 5 -94 28 -90 32 {name=Z dir=inout sim_pinnumber=4}
B 5 90 -32 94 -28 {name=VDD dir=inout sim_pinnumber=5}
B 5 90 -12 94 -8 {name=VNW dir=inout sim_pinnumber=6}
B 5 90 8 94 12 {name=VPW dir=inout sim_pinnumber=7}
B 5 90 28 94 32 {name=VSS dir=inout sim_pinnumber=8}
]
N 313 23970 293 23970 {lab=n_0639}
C {./lab_pin.sym} 293 23970 0 0 {name=l1273_0 lab=n_0639}
N 313 23990 293 23990 {lab=n_0641}
C {./lab_pin.sym} 293 23990 0 0 {name=l1273_1 lab=n_0641}
N 313 24010 293 24010 {lab=n_0642}
C {./lab_pin.sym} 293 24010 0 0 {name=l1273_2 lab=n_0642}
N 313 24030 293 24030 {lab=n_0643}
C {./lab_pin.sym} 293 24030 0 0 {name=l1273_3 lab=n_0643}
N 497 23970 517 23970 {lab=VDD}
C {./lab_pin.sym} 517 23970 0 1 {name=l1273_4 lab=VDD}
N 497 23990 517 23990 {lab=VDD}
C {./lab_pin.sym} 517 23990 0 1 {name=l1273_5 lab=VDD}
N 497 24010 517 24010 {lab=VSS}
C {./lab_pin.sym} 517 24010 0 1 {name=l1273_6 lab=VSS}
N 497 24030 517 24030 {lab=VSS}
C {./lab_pin.sym} 517 24030 0 1 {name=l1273_7 lab=VSS}
C {./oai211_1.sym} 810 24000 0 0 {name=Xn_1215}
N 718 23960 698 23960 {lab=u_cas_int_out_int2_b9}
C {./lab_pin.sym} 698 23960 0 0 {name=l1274_0 lab=u_cas_int_out_int2_b9}
N 718 23980 698 23980 {lab=out_cas_int_b9}
C {./lab_pin.sym} 698 23980 0 0 {name=l1274_1 lab=out_cas_int_b9}
N 718 24000 698 24000 {lab=u_cas_int_out_int2_b8}
C {./lab_pin.sym} 698 24000 0 0 {name=l1274_2 lab=u_cas_int_out_int2_b8}
N 718 24020 698 24020 {lab=out_cas_int_b8}
C {./lab_pin.sym} 698 24020 0 0 {name=l1274_3 lab=out_cas_int_b8}
N 718 24040 698 24040 {lab=n_0644}
C {./lab_pin.sym} 698 24040 0 0 {name=l1274_4 lab=n_0644}
N 902 23970 922 23970 {lab=VDD}
C {./lab_pin.sym} 922 23970 0 1 {name=l1274_5 lab=VDD}
N 902 23990 922 23990 {lab=VDD}
C {./lab_pin.sym} 922 23990 0 1 {name=l1274_6 lab=VDD}
N 902 24010 922 24010 {lab=VSS}
C {./lab_pin.sym} 922 24010 0 1 {name=l1274_7 lab=VSS}
N 902 24030 922 24030 {lab=VSS}
C {./lab_pin.sym} 922 24030 0 1 {name=l1274_8 lab=VSS}
C {./nand2_1.sym} 1215 24000 0 0 {name=Xn_1216}
N 1123 23970 1103 23970 {lab=n_0642}
C {./lab_pin.sym} 1103 23970 0 0 {name=l1275_0 lab=n_0642}
N 1123 23990 1103 23990 {lab=n_0644}
C {./lab_pin.sym} 1103 23990 0 0 {name=l1275_1 lab=n_0644}
N 1123 24010 1103 24010 {lab=n_0645}
C {./lab_pin.sym} 1103 24010 0 0 {name=l1275_2 lab=n_0645}
N 1123 24030 1103 24030 {lab=VDD}
C {./lab_pin.sym} 1103 24030 0 0 {name=l1275_3 lab=VDD}
N 1307 23980 1327 23980 {lab=VDD}
C {./lab_pin.sym} 1327 23980 0 1 {name=l1275_4 lab=VDD}
N 1307 24000 1327 24000 {lab=VSS}
C {./lab_pin.sym} 1327 24000 0 1 {name=l1275_5 lab=VSS}
N 1307 24020 1327 24020 {lab=VSS}
C {./lab_pin.sym} 1327 24020 0 1 {name=l1275_6 lab=VSS}
C {./clkinv_1.sym} 1620 24000 0 0 {name=Xn_1217}
N 1528 23980 1508 23980 {lab=n_0645}
C {./lab_pin.sym} 1508 23980 0 0 {name=l1276_0 lab=n_0645}
N 1528 24000 1508 24000 {lab=n_0646}
C {./lab_pin.sym} 1508 24000 0 0 {name=l1276_1 lab=n_0646}
N 1528 24020 1508 24020 {lab=VDD}
C {./lab_pin.sym} 1508 24020 0 0 {name=l1276_2 lab=VDD}
N 1712 23980 1732 23980 {lab=VDD}
C {./lab_pin.sym} 1732 23980 0 1 {name=l1276_3 lab=VDD}
N 1712 24000 1732 24000 {lab=VSS}
C {./lab_pin.sym} 1732 24000 0 1 {name=l1276_4 lab=VSS}
N 1712 24020 1732 24020 {lab=VSS}
C {./lab_pin.sym} 1732 24020 0 1 {name=l1276_5 lab=VSS}
C {./aoi21_1.sym} 2025 24000 0 0 {name=Xn_1218}
N 1933 23970 1913 23970 {lab=n_0636}
C {./lab_pin.sym} 1913 23970 0 0 {name=l1277_0 lab=n_0636}
N 1933 23990 1913 23990 {lab=n_0643}
C {./lab_pin.sym} 1913 23990 0 0 {name=l1277_1 lab=n_0643}
N 1933 24010 1913 24010 {lab=n_0645}
C {./lab_pin.sym} 1913 24010 0 0 {name=l1277_2 lab=n_0645}
N 1933 24030 1913 24030 {lab=n_0647}
C {./lab_pin.sym} 1913 24030 0 0 {name=l1277_3 lab=n_0647}
N 2117 23970 2137 23970 {lab=VDD}
C {./lab_pin.sym} 2137 23970 0 1 {name=l1277_4 lab=VDD}
N 2117 23990 2137 23990 {lab=VDD}
C {./lab_pin.sym} 2137 23990 0 1 {name=l1277_5 lab=VDD}
N 2117 24010 2137 24010 {lab=VSS}
C {./lab_pin.sym} 2137 24010 0 1 {name=l1277_6 lab=VSS}
N 2117 24030 2137 24030 {lab=VSS}
C {./lab_pin.sym} 2137 24030 0 1 {name=l1277_7 lab=VSS}
C {./or2_1.sym} 2430 24000 0 0 {name=Xn_1219}
N 2338 23970 2318 23970 {lab=u_cas_int_out_int2_b10}
C {./lab_pin.sym} 2318 23970 0 0 {name=l1278_0 lab=u_cas_int_out_int2_b10}
N 2338 23990 2318 23990 {lab=out_cas_int_b10}
C {./lab_pin.sym} 2318 23990 0 0 {name=l1278_1 lab=out_cas_int_b10}
N 2338 24010 2318 24010 {lab=n_0648}
C {./lab_pin.sym} 2318 24010 0 0 {name=l1278_2 lab=n_0648}
N 2338 24030 2318 24030 {lab=VDD}
C {./lab_pin.sym} 2318 24030 0 0 {name=l1278_3 lab=VDD}
N 2522 23980 2542 23980 {lab=VDD}
C {./lab_pin.sym} 2542 23980 0 1 {name=l1278_4 lab=VDD}
N 2522 24000 2542 24000 {lab=VSS}
C {./lab_pin.sym} 2542 24000 0 1 {name=l1278_5 lab=VSS}
N 2522 24020 2542 24020 {lab=VSS}
C {./lab_pin.sym} 2542 24020 0 1 {name=l1278_6 lab=VSS}
C {./and2_1.sym} 2835 24000 0 0 {name=Xn_1220}
N 2743 23970 2723 23970 {lab=u_cas_int_out_int2_b10}
C {./lab_pin.sym} 2723 23970 0 0 {name=l1279_0 lab=u_cas_int_out_int2_b10}
N 2743 23990 2723 23990 {lab=out_cas_int_b10}
C {./lab_pin.sym} 2723 23990 0 0 {name=l1279_1 lab=out_cas_int_b10}
N 2743 24010 2723 24010 {lab=n_0649}
C {./lab_pin.sym} 2723 24010 0 0 {name=l1279_2 lab=n_0649}
N 2743 24030 2723 24030 {lab=VDD}
C {./lab_pin.sym} 2723 24030 0 0 {name=l1279_3 lab=VDD}
N 2927 23980 2947 23980 {lab=VDD}
C {./lab_pin.sym} 2947 23980 0 1 {name=l1279_4 lab=VDD}
N 2927 24000 2947 24000 {lab=VSS}
C {./lab_pin.sym} 2947 24000 0 1 {name=l1279_5 lab=VSS}
N 2927 24020 2947 24020 {lab=VSS}
C {./lab_pin.sym} 2947 24020 0 1 {name=l1279_6 lab=VSS}
C {./nand2_1.sym} 3240 24000 0 0 {name=Xn_1221}
N 3148 23970 3128 23970 {lab=u_cas_int_out_int2_b10}
C {./lab_pin.sym} 3128 23970 0 0 {name=l1280_0 lab=u_cas_int_out_int2_b10}
N 3148 23990 3128 23990 {lab=out_cas_int_b10}
C {./lab_pin.sym} 3128 23990 0 0 {name=l1280_1 lab=out_cas_int_b10}
N 3148 24010 3128 24010 {lab=n_0650}
C {./lab_pin.sym} 3128 24010 0 0 {name=l1280_2 lab=n_0650}
N 3148 24030 3128 24030 {lab=VDD}
C {./lab_pin.sym} 3128 24030 0 0 {name=l1280_3 lab=VDD}
N 3332 23980 3352 23980 {lab=VDD}
C {./lab_pin.sym} 3352 23980 0 1 {name=l1280_4 lab=VDD}
N 3332 24000 3352 24000 {lab=VSS}
C {./lab_pin.sym} 3352 24000 0 1 {name=l1280_5 lab=VSS}
N 3332 24020 3352 24020 {lab=VSS}
C {./lab_pin.sym} 3352 24020 0 1 {name=l1280_6 lab=VSS}
C {./nand2_1.sym} 3645 24000 0 0 {name=Xn_1222}
N 3553 23970 3533 23970 {lab=n_0647}
C {./lab_pin.sym} 3533 23970 0 0 {name=l1281_0 lab=n_0647}
N 3553 23990 3533 23990 {lab=n_0650}
C {./lab_pin.sym} 3533 23990 0 0 {name=l1281_1 lab=n_0650}
N 3553 24010 3533 24010 {lab=n_0651}
C {./lab_pin.sym} 3533 24010 0 0 {name=l1281_2 lab=n_0651}
N 3553 24030 3533 24030 {lab=VDD}
C {./lab_pin.sym} 3533 24030 0 0 {name=l1281_3 lab=VDD}
N 3737 23980 3757 23980 {lab=VDD}
C {./lab_pin.sym} 3757 23980 0 1 {name=l1281_4 lab=VDD}
N 3737 24000 3757 24000 {lab=VSS}
C {./lab_pin.sym} 3757 24000 0 1 {name=l1281_5 lab=VSS}
N 3737 24020 3757 24020 {lab=VSS}
C {./lab_pin.sym} 3757 24020 0 1 {name=l1281_6 lab=VSS}
C {./xor3_1.sym} 4050 24000 0 0 {name=Xn_1223}
N 3958 23970 3938 23970 {lab=u_cas_int_out_int2_b10}
C {./lab_pin.sym} 3938 23970 0 0 {name=l1282_0 lab=u_cas_int_out_int2_b10}
N 3958 23990 3938 23990 {lab=n_0488}
C {./lab_pin.sym} 3938 23990 0 0 {name=l1282_1 lab=n_0488}
N 3958 24010 3938 24010 {lab=n_0647}
C {./lab_pin.sym} 3938 24010 0 0 {name=l1282_2 lab=n_0647}
N 3958 24030 3938 24030 {lab=n_0113}
C {./lab_pin.sym} 3938 24030 0 0 {name=l1282_3 lab=n_0113}
N 4142 23970 4162 23970 {lab=VDD}
C {./lab_pin.sym} 4162 23970 0 1 {name=l1282_4 lab=VDD}
N 4142 23990 4162 23990 {lab=VDD}
C {./lab_pin.sym} 4162 23990 0 1 {name=l1282_5 lab=VDD}
N 4142 24010 4162 24010 {lab=VSS}
C {./lab_pin.sym} 4162 24010 0 1 {name=l1282_6 lab=VSS}
N 4142 24030 4162 24030 {lab=VSS}
C {./lab_pin.sym} 4162 24030 0 1 {name=l1282_7 lab=VSS}
C {./or2_1.sym} 4455 24000 0 0 {name=Xn_1224}
N 4363 23970 4343 23970 {lab=u_cas_int_out_int2_b11}
C {./lab_pin.sym} 4343 23970 0 0 {name=l1283_0 lab=u_cas_int_out_int2_b11}
N 4363 23990 4343 23990 {lab=out_cas_int_b11}
C {./lab_pin.sym} 4343 23990 0 0 {name=l1283_1 lab=out_cas_int_b11}
N 4363 24010 4343 24010 {lab=n_0652}
C {./lab_pin.sym} 4343 24010 0 0 {name=l1283_2 lab=n_0652}
N 4363 24030 4343 24030 {lab=VDD}
C {./lab_pin.sym} 4343 24030 0 0 {name=l1283_3 lab=VDD}
N 4547 23980 4567 23980 {lab=VDD}
C {./lab_pin.sym} 4567 23980 0 1 {name=l1283_4 lab=VDD}
N 4547 24000 4567 24000 {lab=VSS}
C {./lab_pin.sym} 4567 24000 0 1 {name=l1283_5 lab=VSS}
N 4547 24020 4567 24020 {lab=VSS}
C {./lab_pin.sym} 4567 24020 0 1 {name=l1283_6 lab=VSS}
C {./and2_1.sym} 0 24225 0 0 {name=Xn_1225}
N -92 24195 -112 24195 {lab=u_cas_int_out_int2_b11}
C {./lab_pin.sym} -112 24195 0 0 {name=l1284_0 lab=u_cas_int_out_int2_b11}
N -92 24215 -112 24215 {lab=out_cas_int_b11}
C {./lab_pin.sym} -112 24215 0 0 {name=l1284_1 lab=out_cas_int_b11}
N -92 24235 -112 24235 {lab=n_0653}
C {./lab_pin.sym} -112 24235 0 0 {name=l1284_2 lab=n_0653}
N -92 24255 -112 24255 {lab=VDD}
C {./lab_pin.sym} -112 24255 0 0 {name=l1284_3 lab=VDD}
N 92 24205 112 24205 {lab=VDD}
C {./lab_pin.sym} 112 24205 0 1 {name=l1284_4 lab=VDD}
N 92 24225 112 24225 {lab=VSS}
C {./lab_pin.sym} 112 24225 0 1 {name=l1284_5 lab=VSS}
N 92 24245 112 24245 {lab=VSS}
C {./lab_pin.sym} 112 24245 0 1 {name=l1284_6 lab=VSS}
C {./nand2_1.sym} 405 24225 0 0 {name=Xn_1226}
N 313 24195 293 24195 {lab=u_cas_int_out_int2_b11}
C {./lab_pin.sym} 293 24195 0 0 {name=l1285_0 lab=u_cas_int_out_int2_b11}
N 313 24215 293 24215 {lab=out_cas_int_b11}
C {./lab_pin.sym} 293 24215 0 0 {name=l1285_1 lab=out_cas_int_b11}
N 313 24235 293 24235 {lab=n_0654}
C {./lab_pin.sym} 293 24235 0 0 {name=l1285_2 lab=n_0654}
N 313 24255 293 24255 {lab=VDD}
C {./lab_pin.sym} 293 24255 0 0 {name=l1285_3 lab=VDD}
N 497 24205 517 24205 {lab=VDD}
C {./lab_pin.sym} 517 24205 0 1 {name=l1285_4 lab=VDD}
N 497 24225 517 24225 {lab=VSS}
C {./lab_pin.sym} 517 24225 0 1 {name=l1285_5 lab=VSS}
N 497 24245 517 24245 {lab=VSS}
C {./lab_pin.sym} 517 24245 0 1 {name=l1285_6 lab=VSS}
C {./nand2_1.sym} 810 24225 0 0 {name=Xn_1227}
N 718 24195 698 24195 {lab=n_0648}
C {./lab_pin.sym} 698 24195 0 0 {name=l1286_0 lab=n_0648}
N 718 24215 698 24215 {lab=n_0651}
C {./lab_pin.sym} 698 24215 0 0 {name=l1286_1 lab=n_0651}
N 718 24235 698 24235 {lab=n_0655}
C {./lab_pin.sym} 698 24235 0 0 {name=l1286_2 lab=n_0655}
N 718 24255 698 24255 {lab=VDD}
C {./lab_pin.sym} 698 24255 0 0 {name=l1286_3 lab=VDD}
N 902 24205 922 24205 {lab=VDD}
C {./lab_pin.sym} 922 24205 0 1 {name=l1286_4 lab=VDD}
N 902 24225 922 24225 {lab=VSS}
C {./lab_pin.sym} 922 24225 0 1 {name=l1286_5 lab=VSS}
N 902 24245 922 24245 {lab=VSS}
C {./lab_pin.sym} 922 24245 0 1 {name=l1286_6 lab=VSS}
C {./xor3_1.sym} 1215 24225 0 0 {name=Xn_1228}
N 1123 24195 1103 24195 {lab=u_cas_int_out_int2_b11}
C {./lab_pin.sym} 1103 24195 0 0 {name=l1287_0 lab=u_cas_int_out_int2_b11}
N 1123 24215 1103 24215 {lab=n_0489}
C {./lab_pin.sym} 1103 24215 0 0 {name=l1287_1 lab=n_0489}
N 1123 24235 1103 24235 {lab=n_0655}
C {./lab_pin.sym} 1103 24235 0 0 {name=l1287_2 lab=n_0655}
N 1123 24255 1103 24255 {lab=n_0114}
C {./lab_pin.sym} 1103 24255 0 0 {name=l1287_3 lab=n_0114}
N 1307 24195 1327 24195 {lab=VDD}
C {./lab_pin.sym} 1327 24195 0 1 {name=l1287_4 lab=VDD}
N 1307 24215 1327 24215 {lab=VDD}
C {./lab_pin.sym} 1327 24215 0 1 {name=l1287_5 lab=VDD}
N 1307 24235 1327 24235 {lab=VSS}
C {./lab_pin.sym} 1327 24235 0 1 {name=l1287_6 lab=VSS}
N 1307 24255 1327 24255 {lab=VSS}
C {./lab_pin.sym} 1327 24255 0 1 {name=l1287_7 lab=VSS}
C {./nand2_1.sym} 1620 24225 0 0 {name=Xn_1229}
N 1528 24195 1508 24195 {lab=n_0650}
C {./lab_pin.sym} 1508 24195 0 0 {name=l1288_0 lab=n_0650}
N 1528 24215 1508 24215 {lab=n_0654}
C {./lab_pin.sym} 1508 24215 0 0 {name=l1288_1 lab=n_0654}
N 1528 24235 1508 24235 {lab=n_0656}
C {./lab_pin.sym} 1508 24235 0 0 {name=l1288_2 lab=n_0656}
N 1528 24255 1508 24255 {lab=VDD}
C {./lab_pin.sym} 1508 24255 0 0 {name=l1288_3 lab=VDD}
N 1712 24205 1732 24205 {lab=VDD}
C {./lab_pin.sym} 1732 24205 0 1 {name=l1288_4 lab=VDD}
N 1712 24225 1732 24225 {lab=VSS}
C {./lab_pin.sym} 1732 24225 0 1 {name=l1288_5 lab=VSS}
N 1712 24245 1732 24245 {lab=VSS}
C {./lab_pin.sym} 1732 24245 0 1 {name=l1288_6 lab=VSS}
C {./nand2_1.sym} 2025 24225 0 0 {name=Xn_1230}
N 1933 24195 1913 24195 {lab=n_0652}
C {./lab_pin.sym} 1913 24195 0 0 {name=l1289_0 lab=n_0652}
N 1933 24215 1913 24215 {lab=n_0656}
C {./lab_pin.sym} 1913 24215 0 0 {name=l1289_1 lab=n_0656}
N 1933 24235 1913 24235 {lab=n_0657}
C {./lab_pin.sym} 1913 24235 0 0 {name=l1289_2 lab=n_0657}
N 1933 24255 1913 24255 {lab=VDD}
C {./lab_pin.sym} 1913 24255 0 0 {name=l1289_3 lab=VDD}
N 2117 24205 2137 24205 {lab=VDD}
C {./lab_pin.sym} 2137 24205 0 1 {name=l1289_4 lab=VDD}
N 2117 24225 2137 24225 {lab=VSS}
C {./lab_pin.sym} 2137 24225 0 1 {name=l1289_5 lab=VSS}
N 2117 24245 2137 24245 {lab=VSS}
C {./lab_pin.sym} 2137 24245 0 1 {name=l1289_6 lab=VSS}
C {./oai22_1.sym} 2430 24225 0 0 {name=Xn_1231}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__oai22_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -60 72 -60 {}
L 4 72 -60 72 60 {}
L 4 72 60 -72 60 {}
L 4 -72 60 -72 -60 {}
T {@name} -72 -80 0 0 0.33 0.33 {}
T {oai22_1} -68 49 0 0 0.2 0.2 {}
L 4 -92 -40 -72 -40 {}
T {A1} -66 -45 0 0 0.16 0.16 {}
L 4 -92 -20 -72 -20 {}
T {A2} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {B1} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {B2} -66 15 0 0 0.16 0.16 {}
L 4 -92 40 -72 40 {}
T {ZN} -66 35 0 0 0.16 0.16 {}
L 4 92 -30 72 -30 {}
T {VDD} 50.2 -35 0 0 0.16 0.16 {}
L 4 92 -10 72 -10 {}
T {VNW} 50.2 -15 0 0 0.16 0.16 {}
L 4 92 10 72 10 {}
T {VPW} 50.2 5 0 0 0.16 0.16 {}
L 4 92 30 72 30 {}
T {VSS} 50.2 25 0 0 0.16 0.16 {}
B 5 -94 -42 -90 -38 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -22 -90 -18 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 -2 -90 2 {name=B1 dir=inout sim_pinnumber=3}
B 5 -94 18 -90 22 {name=B2 dir=inout sim_pinnumber=4}
B 5 -94 38 -90 42 {name=ZN dir=inout sim_pinnumber=5}
B 5 90 -32 94 -28 {name=VDD dir=inout sim_pinnumber=6}
B 5 90 -12 94 -8 {name=VNW dir=inout sim_pinnumber=7}
B 5 90 8 94 12 {name=VPW dir=inout sim_pinnumber=8}
B 5 90 28 94 32 {name=VSS dir=inout sim_pinnumber=9}
]
N 2338 24185 2318 24185 {lab=u_cas_int_out_int2_b10}
C {./lab_pin.sym} 2318 24185 0 0 {name=l1290_0 lab=u_cas_int_out_int2_b10}
N 2338 24205 2318 24205 {lab=out_cas_int_b10}
C {./lab_pin.sym} 2318 24205 0 0 {name=l1290_1 lab=out_cas_int_b10}
N 2338 24225 2318 24225 {lab=u_cas_int_out_int2_b11}
C {./lab_pin.sym} 2318 24225 0 0 {name=l1290_2 lab=u_cas_int_out_int2_b11}
N 2338 24245 2318 24245 {lab=out_cas_int_b11}
C {./lab_pin.sym} 2318 24245 0 0 {name=l1290_3 lab=out_cas_int_b11}
N 2338 24265 2318 24265 {lab=n_0658}
C {./lab_pin.sym} 2318 24265 0 0 {name=l1290_4 lab=n_0658}
N 2522 24195 2542 24195 {lab=VDD}
C {./lab_pin.sym} 2542 24195 0 1 {name=l1290_5 lab=VDD}
N 2522 24215 2542 24215 {lab=VDD}
C {./lab_pin.sym} 2542 24215 0 1 {name=l1290_6 lab=VDD}
N 2522 24235 2542 24235 {lab=VSS}
C {./lab_pin.sym} 2542 24235 0 1 {name=l1290_7 lab=VSS}
N 2522 24255 2542 24255 {lab=VSS}
C {./lab_pin.sym} 2542 24255 0 1 {name=l1290_8 lab=VSS}
C {./nor3_1.sym} 2835 24225 0 0 {name=Xn_1232}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__nor3_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -50 72 -50 {}
L 4 72 -50 72 50 {}
L 4 72 50 -72 50 {}
L 4 -72 50 -72 -50 {}
T {@name} -72 -70 0 0 0.33 0.33 {}
T {nor3_1} -68 39 0 0 0.2 0.2 {}
L 4 -92 -30 -72 -30 {}
T {A1} -66 -35 0 0 0.16 0.16 {}
L 4 -92 -10 -72 -10 {}
T {A2} -66 -15 0 0 0.16 0.16 {}
L 4 -92 10 -72 10 {}
T {A3} -66 5 0 0 0.16 0.16 {}
L 4 -92 30 -72 30 {}
T {ZN} -66 25 0 0 0.16 0.16 {}
L 4 92 -30 72 -30 {}
T {VDD} 50.2 -35 0 0 0.16 0.16 {}
L 4 92 -10 72 -10 {}
T {VNW} 50.2 -15 0 0 0.16 0.16 {}
L 4 92 10 72 10 {}
T {VPW} 50.2 5 0 0 0.16 0.16 {}
L 4 92 30 72 30 {}
T {VSS} 50.2 25 0 0 0.16 0.16 {}
B 5 -94 -32 -90 -28 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -12 -90 -8 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 8 -90 12 {name=A3 dir=inout sim_pinnumber=3}
B 5 -94 28 -90 32 {name=ZN dir=inout sim_pinnumber=4}
B 5 90 -32 94 -28 {name=VDD dir=inout sim_pinnumber=5}
B 5 90 -12 94 -8 {name=VNW dir=inout sim_pinnumber=6}
B 5 90 8 94 12 {name=VPW dir=inout sim_pinnumber=7}
B 5 90 28 94 32 {name=VSS dir=inout sim_pinnumber=8}
]
N 2743 24195 2723 24195 {lab=n_0658}
C {./lab_pin.sym} 2723 24195 0 0 {name=l1291_0 lab=n_0658}
N 2743 24215 2723 24215 {lab=n_0653}
C {./lab_pin.sym} 2723 24215 0 0 {name=l1291_1 lab=n_0653}
N 2743 24235 2723 24235 {lab=n_0649}
C {./lab_pin.sym} 2723 24235 0 0 {name=l1291_2 lab=n_0649}
N 2743 24255 2723 24255 {lab=n_0659}
C {./lab_pin.sym} 2723 24255 0 0 {name=l1291_3 lab=n_0659}
N 2927 24195 2947 24195 {lab=VDD}
C {./lab_pin.sym} 2947 24195 0 1 {name=l1291_4 lab=VDD}
N 2927 24215 2947 24215 {lab=VDD}
C {./lab_pin.sym} 2947 24215 0 1 {name=l1291_5 lab=VDD}
N 2927 24235 2947 24235 {lab=VSS}
C {./lab_pin.sym} 2947 24235 0 1 {name=l1291_6 lab=VSS}
N 2927 24255 2947 24255 {lab=VSS}
C {./lab_pin.sym} 2947 24255 0 1 {name=l1291_7 lab=VSS}
C {./nand4_1.sym} 3240 24225 0 0 {name=Xn_1233}
N 3148 24185 3128 24185 {lab=n_0648}
C {./lab_pin.sym} 3128 24185 0 0 {name=l1292_0 lab=n_0648}
N 3148 24205 3128 24205 {lab=n_0650}
C {./lab_pin.sym} 3128 24205 0 0 {name=l1292_1 lab=n_0650}
N 3148 24225 3128 24225 {lab=n_0652}
C {./lab_pin.sym} 3128 24225 0 0 {name=l1292_2 lab=n_0652}
N 3148 24245 3128 24245 {lab=n_0654}
C {./lab_pin.sym} 3128 24245 0 0 {name=l1292_3 lab=n_0654}
N 3148 24265 3128 24265 {lab=n_0660}
C {./lab_pin.sym} 3128 24265 0 0 {name=l1292_4 lab=n_0660}
N 3332 24195 3352 24195 {lab=VDD}
C {./lab_pin.sym} 3352 24195 0 1 {name=l1292_5 lab=VDD}
N 3332 24215 3352 24215 {lab=VDD}
C {./lab_pin.sym} 3352 24215 0 1 {name=l1292_6 lab=VDD}
N 3332 24235 3352 24235 {lab=VSS}
C {./lab_pin.sym} 3352 24235 0 1 {name=l1292_7 lab=VSS}
N 3332 24255 3352 24255 {lab=VSS}
C {./lab_pin.sym} 3352 24255 0 1 {name=l1292_8 lab=VSS}
C {./oai21_1.sym} 3645 24225 0 0 {name=Xn_1234}
N 3553 24195 3533 24195 {lab=n_0647}
C {./lab_pin.sym} 3533 24195 0 0 {name=l1293_0 lab=n_0647}
N 3553 24215 3533 24215 {lab=n_0660}
C {./lab_pin.sym} 3533 24215 0 0 {name=l1293_1 lab=n_0660}
N 3553 24235 3533 24235 {lab=n_0657}
C {./lab_pin.sym} 3533 24235 0 0 {name=l1293_2 lab=n_0657}
N 3553 24255 3533 24255 {lab=n_0661}
C {./lab_pin.sym} 3533 24255 0 0 {name=l1293_3 lab=n_0661}
N 3737 24195 3757 24195 {lab=VDD}
C {./lab_pin.sym} 3757 24195 0 1 {name=l1293_4 lab=VDD}
N 3737 24215 3757 24215 {lab=VDD}
C {./lab_pin.sym} 3757 24215 0 1 {name=l1293_5 lab=VDD}
N 3737 24235 3757 24235 {lab=VSS}
C {./lab_pin.sym} 3757 24235 0 1 {name=l1293_6 lab=VSS}
N 3737 24255 3757 24255 {lab=VSS}
C {./lab_pin.sym} 3757 24255 0 1 {name=l1293_7 lab=VSS}
C {./or2_1.sym} 4050 24225 0 0 {name=Xn_1235}
N 3958 24195 3938 24195 {lab=u_cas_int_out_int2_b12}
C {./lab_pin.sym} 3938 24195 0 0 {name=l1294_0 lab=u_cas_int_out_int2_b12}
N 3958 24215 3938 24215 {lab=out_cas_int_b12}
C {./lab_pin.sym} 3938 24215 0 0 {name=l1294_1 lab=out_cas_int_b12}
N 3958 24235 3938 24235 {lab=n_0662}
C {./lab_pin.sym} 3938 24235 0 0 {name=l1294_2 lab=n_0662}
N 3958 24255 3938 24255 {lab=VDD}
C {./lab_pin.sym} 3938 24255 0 0 {name=l1294_3 lab=VDD}
N 4142 24205 4162 24205 {lab=VDD}
C {./lab_pin.sym} 4162 24205 0 1 {name=l1294_4 lab=VDD}
N 4142 24225 4162 24225 {lab=VSS}
C {./lab_pin.sym} 4162 24225 0 1 {name=l1294_5 lab=VSS}
N 4142 24245 4162 24245 {lab=VSS}
C {./lab_pin.sym} 4162 24245 0 1 {name=l1294_6 lab=VSS}
C {./nand2_1.sym} 4455 24225 0 0 {name=Xn_1236}
N 4363 24195 4343 24195 {lab=u_cas_int_out_int2_b12}
C {./lab_pin.sym} 4343 24195 0 0 {name=l1295_0 lab=u_cas_int_out_int2_b12}
N 4363 24215 4343 24215 {lab=out_cas_int_b12}
C {./lab_pin.sym} 4343 24215 0 0 {name=l1295_1 lab=out_cas_int_b12}
N 4363 24235 4343 24235 {lab=n_0663}
C {./lab_pin.sym} 4343 24235 0 0 {name=l1295_2 lab=n_0663}
N 4363 24255 4343 24255 {lab=VDD}
C {./lab_pin.sym} 4343 24255 0 0 {name=l1295_3 lab=VDD}
N 4547 24205 4567 24205 {lab=VDD}
C {./lab_pin.sym} 4567 24205 0 1 {name=l1295_4 lab=VDD}
N 4547 24225 4567 24225 {lab=VSS}
C {./lab_pin.sym} 4567 24225 0 1 {name=l1295_5 lab=VSS}
N 4547 24245 4567 24245 {lab=VSS}
C {./lab_pin.sym} 4567 24245 0 1 {name=l1295_6 lab=VSS}
C {./xor3_1.sym} 0 24450 0 0 {name=Xn_1237}
N -92 24420 -112 24420 {lab=u_cas_int_out_int2_b12}
C {./lab_pin.sym} -112 24420 0 0 {name=l1296_0 lab=u_cas_int_out_int2_b12}
N -92 24440 -112 24440 {lab=out_cas_int_b12}
C {./lab_pin.sym} -112 24440 0 0 {name=l1296_1 lab=out_cas_int_b12}
N -92 24460 -112 24460 {lab=n_0661}
C {./lab_pin.sym} -112 24460 0 0 {name=l1296_2 lab=n_0661}
N -92 24480 -112 24480 {lab=n_0115}
C {./lab_pin.sym} -112 24480 0 0 {name=l1296_3 lab=n_0115}
N 92 24420 112 24420 {lab=VDD}
C {./lab_pin.sym} 112 24420 0 1 {name=l1296_4 lab=VDD}
N 92 24440 112 24440 {lab=VDD}
C {./lab_pin.sym} 112 24440 0 1 {name=l1296_5 lab=VDD}
N 92 24460 112 24460 {lab=VSS}
C {./lab_pin.sym} 112 24460 0 1 {name=l1296_6 lab=VSS}
N 92 24480 112 24480 {lab=VSS}
C {./lab_pin.sym} 112 24480 0 1 {name=l1296_7 lab=VSS}
C {./or2_1.sym} 405 24450 0 0 {name=Xn_1238}
N 313 24420 293 24420 {lab=u_cas_int_out_int2_b13}
C {./lab_pin.sym} 293 24420 0 0 {name=l1297_0 lab=u_cas_int_out_int2_b13}
N 313 24440 293 24440 {lab=out_cas_int_b13}
C {./lab_pin.sym} 293 24440 0 0 {name=l1297_1 lab=out_cas_int_b13}
N 313 24460 293 24460 {lab=n_0664}
C {./lab_pin.sym} 293 24460 0 0 {name=l1297_2 lab=n_0664}
N 313 24480 293 24480 {lab=VDD}
C {./lab_pin.sym} 293 24480 0 0 {name=l1297_3 lab=VDD}
N 497 24430 517 24430 {lab=VDD}
C {./lab_pin.sym} 517 24430 0 1 {name=l1297_4 lab=VDD}
N 497 24450 517 24450 {lab=VSS}
C {./lab_pin.sym} 517 24450 0 1 {name=l1297_5 lab=VSS}
N 497 24470 517 24470 {lab=VSS}
C {./lab_pin.sym} 517 24470 0 1 {name=l1297_6 lab=VSS}
C {./nand2_1.sym} 810 24450 0 0 {name=Xn_1239}
N 718 24420 698 24420 {lab=u_cas_int_out_int2_b13}
C {./lab_pin.sym} 698 24420 0 0 {name=l1298_0 lab=u_cas_int_out_int2_b13}
N 718 24440 698 24440 {lab=out_cas_int_b13}
C {./lab_pin.sym} 698 24440 0 0 {name=l1298_1 lab=out_cas_int_b13}
N 718 24460 698 24460 {lab=n_0665}
C {./lab_pin.sym} 698 24460 0 0 {name=l1298_2 lab=n_0665}
N 718 24480 698 24480 {lab=VDD}
C {./lab_pin.sym} 698 24480 0 0 {name=l1298_3 lab=VDD}
N 902 24430 922 24430 {lab=VDD}
C {./lab_pin.sym} 922 24430 0 1 {name=l1298_4 lab=VDD}
N 902 24450 922 24450 {lab=VSS}
C {./lab_pin.sym} 922 24450 0 1 {name=l1298_5 lab=VSS}
N 902 24470 922 24470 {lab=VSS}
C {./lab_pin.sym} 922 24470 0 1 {name=l1298_6 lab=VSS}
C {./oai211_1.sym} 1215 24450 0 0 {name=Xn_1240}
N 1123 24410 1103 24410 {lab=n_0647}
C {./lab_pin.sym} 1103 24410 0 0 {name=l1299_0 lab=n_0647}
N 1123 24430 1103 24430 {lab=n_0660}
C {./lab_pin.sym} 1103 24430 0 0 {name=l1299_1 lab=n_0660}
N 1123 24450 1103 24450 {lab=n_0663}
C {./lab_pin.sym} 1103 24450 0 0 {name=l1299_2 lab=n_0663}
N 1123 24470 1103 24470 {lab=n_0657}
C {./lab_pin.sym} 1103 24470 0 0 {name=l1299_3 lab=n_0657}
N 1123 24490 1103 24490 {lab=n_0666}
C {./lab_pin.sym} 1103 24490 0 0 {name=l1299_4 lab=n_0666}
N 1307 24420 1327 24420 {lab=VDD}
C {./lab_pin.sym} 1327 24420 0 1 {name=l1299_5 lab=VDD}
N 1307 24440 1327 24440 {lab=VDD}
C {./lab_pin.sym} 1327 24440 0 1 {name=l1299_6 lab=VDD}
N 1307 24460 1327 24460 {lab=VSS}
C {./lab_pin.sym} 1327 24460 0 1 {name=l1299_7 lab=VSS}
N 1307 24480 1327 24480 {lab=VSS}
C {./lab_pin.sym} 1327 24480 0 1 {name=l1299_8 lab=VSS}
C {./nand2_1.sym} 1620 24450 0 0 {name=Xn_1241}
N 1528 24420 1508 24420 {lab=n_0662}
C {./lab_pin.sym} 1508 24420 0 0 {name=l1300_0 lab=n_0662}
N 1528 24440 1508 24440 {lab=n_0666}
C {./lab_pin.sym} 1508 24440 0 0 {name=l1300_1 lab=n_0666}
N 1528 24460 1508 24460 {lab=n_0667}
C {./lab_pin.sym} 1508 24460 0 0 {name=l1300_2 lab=n_0667}
N 1528 24480 1508 24480 {lab=VDD}
C {./lab_pin.sym} 1508 24480 0 0 {name=l1300_3 lab=VDD}
N 1712 24430 1732 24430 {lab=VDD}
C {./lab_pin.sym} 1732 24430 0 1 {name=l1300_4 lab=VDD}
N 1712 24450 1732 24450 {lab=VSS}
C {./lab_pin.sym} 1732 24450 0 1 {name=l1300_5 lab=VSS}
N 1712 24470 1732 24470 {lab=VSS}
C {./lab_pin.sym} 1732 24470 0 1 {name=l1300_6 lab=VSS}
C {./xor3_1.sym} 2025 24450 0 0 {name=Xn_1242}
N 1933 24420 1913 24420 {lab=u_cas_int_out_int2_b13}
C {./lab_pin.sym} 1913 24420 0 0 {name=l1301_0 lab=u_cas_int_out_int2_b13}
N 1933 24440 1913 24440 {lab=n_0491}
C {./lab_pin.sym} 1913 24440 0 0 {name=l1301_1 lab=n_0491}
N 1933 24460 1913 24460 {lab=n_0667}
C {./lab_pin.sym} 1913 24460 0 0 {name=l1301_2 lab=n_0667}
N 1933 24480 1913 24480 {lab=n_0116}
C {./lab_pin.sym} 1913 24480 0 0 {name=l1301_3 lab=n_0116}
N 2117 24420 2137 24420 {lab=VDD}
C {./lab_pin.sym} 2137 24420 0 1 {name=l1301_4 lab=VDD}
N 2117 24440 2137 24440 {lab=VDD}
C {./lab_pin.sym} 2137 24440 0 1 {name=l1301_5 lab=VDD}
N 2117 24460 2137 24460 {lab=VSS}
C {./lab_pin.sym} 2137 24460 0 1 {name=l1301_6 lab=VSS}
N 2117 24480 2137 24480 {lab=VSS}
C {./lab_pin.sym} 2137 24480 0 1 {name=l1301_7 lab=VSS}
C {./and4_1.sym} 2430 24450 0 0 {name=Xn_1243}
N 2338 24410 2318 24410 {lab=n_0662}
C {./lab_pin.sym} 2318 24410 0 0 {name=l1302_0 lab=n_0662}
N 2338 24430 2318 24430 {lab=n_0663}
C {./lab_pin.sym} 2318 24430 0 0 {name=l1302_1 lab=n_0663}
N 2338 24450 2318 24450 {lab=n_0664}
C {./lab_pin.sym} 2318 24450 0 0 {name=l1302_2 lab=n_0664}
N 2338 24470 2318 24470 {lab=n_0665}
C {./lab_pin.sym} 2318 24470 0 0 {name=l1302_3 lab=n_0665}
N 2338 24490 2318 24490 {lab=n_0668}
C {./lab_pin.sym} 2318 24490 0 0 {name=l1302_4 lab=n_0668}
N 2522 24420 2542 24420 {lab=VDD}
C {./lab_pin.sym} 2542 24420 0 1 {name=l1302_5 lab=VDD}
N 2522 24440 2542 24440 {lab=VDD}
C {./lab_pin.sym} 2542 24440 0 1 {name=l1302_6 lab=VDD}
N 2522 24460 2542 24460 {lab=VSS}
C {./lab_pin.sym} 2542 24460 0 1 {name=l1302_7 lab=VSS}
N 2522 24480 2542 24480 {lab=VSS}
C {./lab_pin.sym} 2542 24480 0 1 {name=l1302_8 lab=VSS}
C {./nand2_1.sym} 2835 24450 0 0 {name=Xn_1244}
N 2743 24420 2723 24420 {lab=n_0663}
C {./lab_pin.sym} 2723 24420 0 0 {name=l1303_0 lab=n_0663}
N 2743 24440 2723 24440 {lab=n_0665}
C {./lab_pin.sym} 2723 24440 0 0 {name=l1303_1 lab=n_0665}
N 2743 24460 2723 24460 {lab=n_0669}
C {./lab_pin.sym} 2723 24460 0 0 {name=l1303_2 lab=n_0669}
N 2743 24480 2723 24480 {lab=VDD}
C {./lab_pin.sym} 2723 24480 0 0 {name=l1303_3 lab=VDD}
N 2927 24430 2947 24430 {lab=VDD}
C {./lab_pin.sym} 2947 24430 0 1 {name=l1303_4 lab=VDD}
N 2927 24450 2947 24450 {lab=VSS}
C {./lab_pin.sym} 2947 24450 0 1 {name=l1303_5 lab=VSS}
N 2927 24470 2947 24470 {lab=VSS}
C {./lab_pin.sym} 2947 24470 0 1 {name=l1303_6 lab=VSS}
C {./and2_1.sym} 3240 24450 0 0 {name=Xn_1245}
N 3148 24420 3128 24420 {lab=n_0664}
C {./lab_pin.sym} 3128 24420 0 0 {name=l1304_0 lab=n_0664}
N 3148 24440 3128 24440 {lab=n_0669}
C {./lab_pin.sym} 3128 24440 0 0 {name=l1304_1 lab=n_0669}
N 3148 24460 3128 24460 {lab=n_0670}
C {./lab_pin.sym} 3128 24460 0 0 {name=l1304_2 lab=n_0670}
N 3148 24480 3128 24480 {lab=VDD}
C {./lab_pin.sym} 3128 24480 0 0 {name=l1304_3 lab=VDD}
N 3332 24430 3352 24430 {lab=VDD}
C {./lab_pin.sym} 3352 24430 0 1 {name=l1304_4 lab=VDD}
N 3332 24450 3352 24450 {lab=VSS}
C {./lab_pin.sym} 3352 24450 0 1 {name=l1304_5 lab=VSS}
N 3332 24470 3352 24470 {lab=VSS}
C {./lab_pin.sym} 3352 24470 0 1 {name=l1304_6 lab=VSS}
C {./nand2_1.sym} 3645 24450 0 0 {name=Xn_1246}
N 3553 24420 3533 24420 {lab=n_0664}
C {./lab_pin.sym} 3533 24420 0 0 {name=l1305_0 lab=n_0664}
N 3553 24440 3533 24440 {lab=n_0669}
C {./lab_pin.sym} 3533 24440 0 0 {name=l1305_1 lab=n_0669}
N 3553 24460 3533 24460 {lab=n_0671}
C {./lab_pin.sym} 3533 24460 0 0 {name=l1305_2 lab=n_0671}
N 3553 24480 3533 24480 {lab=VDD}
C {./lab_pin.sym} 3533 24480 0 0 {name=l1305_3 lab=VDD}
N 3737 24430 3757 24430 {lab=VDD}
C {./lab_pin.sym} 3757 24430 0 1 {name=l1305_4 lab=VDD}
N 3737 24450 3757 24450 {lab=VSS}
C {./lab_pin.sym} 3757 24450 0 1 {name=l1305_5 lab=VSS}
N 3737 24470 3757 24470 {lab=VSS}
C {./lab_pin.sym} 3757 24470 0 1 {name=l1305_6 lab=VSS}
C {./aoi21_1.sym} 4050 24450 0 0 {name=Xn_1247}
N 3958 24420 3938 24420 {lab=n_0661}
C {./lab_pin.sym} 3938 24420 0 0 {name=l1306_0 lab=n_0661}
N 3958 24440 3938 24440 {lab=n_0668}
C {./lab_pin.sym} 3938 24440 0 0 {name=l1306_1 lab=n_0668}
N 3958 24460 3938 24460 {lab=n_0670}
C {./lab_pin.sym} 3938 24460 0 0 {name=l1306_2 lab=n_0670}
N 3958 24480 3938 24480 {lab=n_0672}
C {./lab_pin.sym} 3938 24480 0 0 {name=l1306_3 lab=n_0672}
N 4142 24420 4162 24420 {lab=VDD}
C {./lab_pin.sym} 4162 24420 0 1 {name=l1306_4 lab=VDD}
N 4142 24440 4162 24440 {lab=VDD}
C {./lab_pin.sym} 4162 24440 0 1 {name=l1306_5 lab=VDD}
N 4142 24460 4162 24460 {lab=VSS}
C {./lab_pin.sym} 4162 24460 0 1 {name=l1306_6 lab=VSS}
N 4142 24480 4162 24480 {lab=VSS}
C {./lab_pin.sym} 4162 24480 0 1 {name=l1306_7 lab=VSS}
C {./or2_1.sym} 4455 24450 0 0 {name=Xn_1248}
N 4363 24420 4343 24420 {lab=u_cas_int_out_int2_b14}
C {./lab_pin.sym} 4343 24420 0 0 {name=l1307_0 lab=u_cas_int_out_int2_b14}
N 4363 24440 4343 24440 {lab=out_cas_int_b14}
C {./lab_pin.sym} 4343 24440 0 0 {name=l1307_1 lab=out_cas_int_b14}
N 4363 24460 4343 24460 {lab=n_0673}
C {./lab_pin.sym} 4343 24460 0 0 {name=l1307_2 lab=n_0673}
N 4363 24480 4343 24480 {lab=VDD}
C {./lab_pin.sym} 4343 24480 0 0 {name=l1307_3 lab=VDD}
N 4547 24430 4567 24430 {lab=VDD}
C {./lab_pin.sym} 4567 24430 0 1 {name=l1307_4 lab=VDD}
N 4547 24450 4567 24450 {lab=VSS}
C {./lab_pin.sym} 4567 24450 0 1 {name=l1307_5 lab=VSS}
N 4547 24470 4567 24470 {lab=VSS}
C {./lab_pin.sym} 4567 24470 0 1 {name=l1307_6 lab=VSS}
C {./nand2_1.sym} 0 24675 0 0 {name=Xn_1249}
N -92 24645 -112 24645 {lab=u_cas_int_out_int2_b14}
C {./lab_pin.sym} -112 24645 0 0 {name=l1308_0 lab=u_cas_int_out_int2_b14}
N -92 24665 -112 24665 {lab=out_cas_int_b14}
C {./lab_pin.sym} -112 24665 0 0 {name=l1308_1 lab=out_cas_int_b14}
N -92 24685 -112 24685 {lab=n_0674}
C {./lab_pin.sym} -112 24685 0 0 {name=l1308_2 lab=n_0674}
N -92 24705 -112 24705 {lab=VDD}
C {./lab_pin.sym} -112 24705 0 0 {name=l1308_3 lab=VDD}
N 92 24655 112 24655 {lab=VDD}
C {./lab_pin.sym} 112 24655 0 1 {name=l1308_4 lab=VDD}
N 92 24675 112 24675 {lab=VSS}
C {./lab_pin.sym} 112 24675 0 1 {name=l1308_5 lab=VSS}
N 92 24695 112 24695 {lab=VSS}
C {./lab_pin.sym} 112 24695 0 1 {name=l1308_6 lab=VSS}
C {./nand2_1.sym} 405 24675 0 0 {name=Xn_1250}
N 313 24645 293 24645 {lab=n_0673}
C {./lab_pin.sym} 293 24645 0 0 {name=l1309_0 lab=n_0673}
N 313 24665 293 24665 {lab=n_0674}
C {./lab_pin.sym} 293 24665 0 0 {name=l1309_1 lab=n_0674}
N 313 24685 293 24685 {lab=n_0675}
C {./lab_pin.sym} 293 24685 0 0 {name=l1309_2 lab=n_0675}
N 313 24705 293 24705 {lab=VDD}
C {./lab_pin.sym} 293 24705 0 0 {name=l1309_3 lab=VDD}
N 497 24655 517 24655 {lab=VDD}
C {./lab_pin.sym} 517 24655 0 1 {name=l1309_4 lab=VDD}
N 497 24675 517 24675 {lab=VSS}
C {./lab_pin.sym} 517 24675 0 1 {name=l1309_5 lab=VSS}
N 497 24695 517 24695 {lab=VSS}
C {./lab_pin.sym} 517 24695 0 1 {name=l1309_6 lab=VSS}
C {./xor2_1.sym} 810 24675 0 0 {name=Xn_1251}
N 718 24645 698 24645 {lab=n_0672}
C {./lab_pin.sym} 698 24645 0 0 {name=l1310_0 lab=n_0672}
N 718 24665 698 24665 {lab=n_0675}
C {./lab_pin.sym} 698 24665 0 0 {name=l1310_1 lab=n_0675}
N 718 24685 698 24685 {lab=n_0117}
C {./lab_pin.sym} 698 24685 0 0 {name=l1310_2 lab=n_0117}
N 718 24705 698 24705 {lab=VDD}
C {./lab_pin.sym} 698 24705 0 0 {name=l1310_3 lab=VDD}
N 902 24655 922 24655 {lab=VDD}
C {./lab_pin.sym} 922 24655 0 1 {name=l1310_4 lab=VDD}
N 902 24675 922 24675 {lab=VSS}
C {./lab_pin.sym} 922 24675 0 1 {name=l1310_5 lab=VSS}
N 902 24695 922 24695 {lab=VSS}
C {./lab_pin.sym} 922 24695 0 1 {name=l1310_6 lab=VSS}
C {./nor2_1.sym} 1215 24675 0 0 {name=Xn_1252}
N 1123 24645 1103 24645 {lab=u_cas_int_out_int2_b15}
C {./lab_pin.sym} 1103 24645 0 0 {name=l1311_0 lab=u_cas_int_out_int2_b15}
N 1123 24665 1103 24665 {lab=out_cas_int_b15}
C {./lab_pin.sym} 1103 24665 0 0 {name=l1311_1 lab=out_cas_int_b15}
N 1123 24685 1103 24685 {lab=n_0676}
C {./lab_pin.sym} 1103 24685 0 0 {name=l1311_2 lab=n_0676}
N 1123 24705 1103 24705 {lab=VDD}
C {./lab_pin.sym} 1103 24705 0 0 {name=l1311_3 lab=VDD}
N 1307 24655 1327 24655 {lab=VDD}
C {./lab_pin.sym} 1327 24655 0 1 {name=l1311_4 lab=VDD}
N 1307 24675 1327 24675 {lab=VSS}
C {./lab_pin.sym} 1327 24675 0 1 {name=l1311_5 lab=VSS}
N 1307 24695 1327 24695 {lab=VSS}
C {./lab_pin.sym} 1327 24695 0 1 {name=l1311_6 lab=VSS}
C {./or2_1.sym} 1620 24675 0 0 {name=Xn_1253}
N 1528 24645 1508 24645 {lab=u_cas_int_out_int2_b15}
C {./lab_pin.sym} 1508 24645 0 0 {name=l1312_0 lab=u_cas_int_out_int2_b15}
N 1528 24665 1508 24665 {lab=out_cas_int_b15}
C {./lab_pin.sym} 1508 24665 0 0 {name=l1312_1 lab=out_cas_int_b15}
N 1528 24685 1508 24685 {lab=n_0677}
C {./lab_pin.sym} 1508 24685 0 0 {name=l1312_2 lab=n_0677}
N 1528 24705 1508 24705 {lab=VDD}
C {./lab_pin.sym} 1508 24705 0 0 {name=l1312_3 lab=VDD}
N 1712 24655 1732 24655 {lab=VDD}
C {./lab_pin.sym} 1732 24655 0 1 {name=l1312_4 lab=VDD}
N 1712 24675 1732 24675 {lab=VSS}
C {./lab_pin.sym} 1732 24675 0 1 {name=l1312_5 lab=VSS}
N 1712 24695 1732 24695 {lab=VSS}
C {./lab_pin.sym} 1732 24695 0 1 {name=l1312_6 lab=VSS}
C {./nand2_1.sym} 2025 24675 0 0 {name=Xn_1254}
N 1933 24645 1913 24645 {lab=u_cas_int_out_int2_b15}
C {./lab_pin.sym} 1913 24645 0 0 {name=l1313_0 lab=u_cas_int_out_int2_b15}
N 1933 24665 1913 24665 {lab=out_cas_int_b15}
C {./lab_pin.sym} 1913 24665 0 0 {name=l1313_1 lab=out_cas_int_b15}
N 1933 24685 1913 24685 {lab=n_0678}
C {./lab_pin.sym} 1913 24685 0 0 {name=l1313_2 lab=n_0678}
N 1933 24705 1913 24705 {lab=VDD}
C {./lab_pin.sym} 1913 24705 0 0 {name=l1313_3 lab=VDD}
N 2117 24655 2137 24655 {lab=VDD}
C {./lab_pin.sym} 2137 24655 0 1 {name=l1313_4 lab=VDD}
N 2117 24675 2137 24675 {lab=VSS}
C {./lab_pin.sym} 2137 24675 0 1 {name=l1313_5 lab=VSS}
N 2117 24695 2137 24695 {lab=VSS}
C {./lab_pin.sym} 2137 24695 0 1 {name=l1313_6 lab=VSS}
C {./nand2_1.sym} 2430 24675 0 0 {name=Xn_1255}
N 2338 24645 2318 24645 {lab=n_0677}
C {./lab_pin.sym} 2318 24645 0 0 {name=l1314_0 lab=n_0677}
N 2338 24665 2318 24665 {lab=n_0678}
C {./lab_pin.sym} 2318 24665 0 0 {name=l1314_1 lab=n_0678}
N 2338 24685 2318 24685 {lab=n_0679}
C {./lab_pin.sym} 2318 24685 0 0 {name=l1314_2 lab=n_0679}
N 2338 24705 2318 24705 {lab=VDD}
C {./lab_pin.sym} 2318 24705 0 0 {name=l1314_3 lab=VDD}
N 2522 24655 2542 24655 {lab=VDD}
C {./lab_pin.sym} 2542 24655 0 1 {name=l1314_4 lab=VDD}
N 2522 24675 2542 24675 {lab=VSS}
C {./lab_pin.sym} 2542 24675 0 1 {name=l1314_5 lab=VSS}
N 2522 24695 2542 24695 {lab=VSS}
C {./lab_pin.sym} 2542 24695 0 1 {name=l1314_6 lab=VSS}
C {./oai21_1.sym} 2835 24675 0 0 {name=Xn_1256}
N 2743 24645 2723 24645 {lab=n_0672}
C {./lab_pin.sym} 2723 24645 0 0 {name=l1315_0 lab=n_0672}
N 2743 24665 2723 24665 {lab=n_0675}
C {./lab_pin.sym} 2723 24665 0 0 {name=l1315_1 lab=n_0675}
N 2743 24685 2723 24685 {lab=n_0674}
C {./lab_pin.sym} 2723 24685 0 0 {name=l1315_2 lab=n_0674}
N 2743 24705 2723 24705 {lab=n_0680}
C {./lab_pin.sym} 2723 24705 0 0 {name=l1315_3 lab=n_0680}
N 2927 24645 2947 24645 {lab=VDD}
C {./lab_pin.sym} 2947 24645 0 1 {name=l1315_4 lab=VDD}
N 2927 24665 2947 24665 {lab=VDD}
C {./lab_pin.sym} 2947 24665 0 1 {name=l1315_5 lab=VDD}
N 2927 24685 2947 24685 {lab=VSS}
C {./lab_pin.sym} 2947 24685 0 1 {name=l1315_6 lab=VSS}
N 2927 24705 2947 24705 {lab=VSS}
C {./lab_pin.sym} 2947 24705 0 1 {name=l1315_7 lab=VSS}
C {./nand2_1.sym} 3240 24675 0 0 {name=Xn_1257}
N 3148 24645 3128 24645 {lab=n_0679}
C {./lab_pin.sym} 3128 24645 0 0 {name=l1316_0 lab=n_0679}
N 3148 24665 3128 24665 {lab=n_0680}
C {./lab_pin.sym} 3128 24665 0 0 {name=l1316_1 lab=n_0680}
N 3148 24685 3128 24685 {lab=n_0681}
C {./lab_pin.sym} 3128 24685 0 0 {name=l1316_2 lab=n_0681}
N 3148 24705 3128 24705 {lab=VDD}
C {./lab_pin.sym} 3128 24705 0 0 {name=l1316_3 lab=VDD}
N 3332 24655 3352 24655 {lab=VDD}
C {./lab_pin.sym} 3352 24655 0 1 {name=l1316_4 lab=VDD}
N 3332 24675 3352 24675 {lab=VSS}
C {./lab_pin.sym} 3352 24675 0 1 {name=l1316_5 lab=VSS}
N 3332 24695 3352 24695 {lab=VSS}
C {./lab_pin.sym} 3352 24695 0 1 {name=l1316_6 lab=VSS}
C {./aoi21_1.sym} 3645 24675 0 0 {name=Xn_1258}
N 3553 24645 3533 24645 {lab=u_cas_int_out_int2_b14}
C {./lab_pin.sym} 3533 24645 0 0 {name=l1317_0 lab=u_cas_int_out_int2_b14}
N 3553 24665 3533 24665 {lab=out_cas_int_b14}
C {./lab_pin.sym} 3533 24665 0 0 {name=l1317_1 lab=out_cas_int_b14}
N 3553 24685 3533 24685 {lab=n_0679}
C {./lab_pin.sym} 3533 24685 0 0 {name=l1317_2 lab=n_0679}
N 3553 24705 3533 24705 {lab=n_0682}
C {./lab_pin.sym} 3533 24705 0 0 {name=l1317_3 lab=n_0682}
N 3737 24645 3757 24645 {lab=VDD}
C {./lab_pin.sym} 3757 24645 0 1 {name=l1317_4 lab=VDD}
N 3737 24665 3757 24665 {lab=VDD}
C {./lab_pin.sym} 3757 24665 0 1 {name=l1317_5 lab=VDD}
N 3737 24685 3757 24685 {lab=VSS}
C {./lab_pin.sym} 3757 24685 0 1 {name=l1317_6 lab=VSS}
N 3737 24705 3757 24705 {lab=VSS}
C {./lab_pin.sym} 3757 24705 0 1 {name=l1317_7 lab=VSS}
C {./oai21_1.sym} 4050 24675 0 0 {name=Xn_1259}
N 3958 24645 3938 24645 {lab=n_0672}
C {./lab_pin.sym} 3938 24645 0 0 {name=l1318_0 lab=n_0672}
N 3958 24665 3938 24665 {lab=n_0675}
C {./lab_pin.sym} 3938 24665 0 0 {name=l1318_1 lab=n_0675}
N 3958 24685 3938 24685 {lab=n_0682}
C {./lab_pin.sym} 3938 24685 0 0 {name=l1318_2 lab=n_0682}
N 3958 24705 3938 24705 {lab=n_0683}
C {./lab_pin.sym} 3938 24705 0 0 {name=l1318_3 lab=n_0683}
N 4142 24645 4162 24645 {lab=VDD}
C {./lab_pin.sym} 4162 24645 0 1 {name=l1318_4 lab=VDD}
N 4142 24665 4162 24665 {lab=VDD}
C {./lab_pin.sym} 4162 24665 0 1 {name=l1318_5 lab=VDD}
N 4142 24685 4162 24685 {lab=VSS}
C {./lab_pin.sym} 4162 24685 0 1 {name=l1318_6 lab=VSS}
N 4142 24705 4162 24705 {lab=VSS}
C {./lab_pin.sym} 4162 24705 0 1 {name=l1318_7 lab=VSS}
C {./nand2_1.sym} 4455 24675 0 0 {name=Xn_1260}
N 4363 24645 4343 24645 {lab=n_0681}
C {./lab_pin.sym} 4343 24645 0 0 {name=l1319_0 lab=n_0681}
N 4363 24665 4343 24665 {lab=n_0683}
C {./lab_pin.sym} 4343 24665 0 0 {name=l1319_1 lab=n_0683}
N 4363 24685 4343 24685 {lab=n_0118}
C {./lab_pin.sym} 4343 24685 0 0 {name=l1319_2 lab=n_0118}
N 4363 24705 4343 24705 {lab=VDD}
C {./lab_pin.sym} 4343 24705 0 0 {name=l1319_3 lab=VDD}
N 4547 24655 4567 24655 {lab=VDD}
C {./lab_pin.sym} 4567 24655 0 1 {name=l1319_4 lab=VDD}
N 4547 24675 4567 24675 {lab=VSS}
C {./lab_pin.sym} 4567 24675 0 1 {name=l1319_5 lab=VSS}
N 4547 24695 4567 24695 {lab=VSS}
C {./lab_pin.sym} 4567 24695 0 1 {name=l1319_6 lab=VSS}
C {./nand2_1.sym} 0 24900 0 0 {name=Xn_1261}
N -92 24870 -112 24870 {lab=u_cas_int_out_int2_b16}
C {./lab_pin.sym} -112 24870 0 0 {name=l1320_0 lab=u_cas_int_out_int2_b16}
N -92 24890 -112 24890 {lab=out_cas_int_b16}
C {./lab_pin.sym} -112 24890 0 0 {name=l1320_1 lab=out_cas_int_b16}
N -92 24910 -112 24910 {lab=n_0684}
C {./lab_pin.sym} -112 24910 0 0 {name=l1320_2 lab=n_0684}
N -92 24930 -112 24930 {lab=VDD}
C {./lab_pin.sym} -112 24930 0 0 {name=l1320_3 lab=VDD}
N 92 24880 112 24880 {lab=VDD}
C {./lab_pin.sym} 112 24880 0 1 {name=l1320_4 lab=VDD}
N 92 24900 112 24900 {lab=VSS}
C {./lab_pin.sym} 112 24900 0 1 {name=l1320_5 lab=VSS}
N 92 24920 112 24920 {lab=VSS}
C {./lab_pin.sym} 112 24920 0 1 {name=l1320_6 lab=VSS}
C {./xor2_1.sym} 405 24900 0 0 {name=Xn_1262}
N 313 24870 293 24870 {lab=u_cas_int_out_int2_b16}
C {./lab_pin.sym} 293 24870 0 0 {name=l1321_0 lab=u_cas_int_out_int2_b16}
N 313 24890 293 24890 {lab=out_cas_int_b16}
C {./lab_pin.sym} 293 24890 0 0 {name=l1321_1 lab=out_cas_int_b16}
N 313 24910 293 24910 {lab=n_0685}
C {./lab_pin.sym} 293 24910 0 0 {name=l1321_2 lab=n_0685}
N 313 24930 293 24930 {lab=VDD}
C {./lab_pin.sym} 293 24930 0 0 {name=l1321_3 lab=VDD}
N 497 24880 517 24880 {lab=VDD}
C {./lab_pin.sym} 517 24880 0 1 {name=l1321_4 lab=VDD}
N 497 24900 517 24900 {lab=VSS}
C {./lab_pin.sym} 517 24900 0 1 {name=l1321_5 lab=VSS}
N 497 24920 517 24920 {lab=VSS}
C {./lab_pin.sym} 517 24920 0 1 {name=l1321_6 lab=VSS}
C {./aoi22_1.sym} 810 24900 0 0 {name=Xn_1263}
N 718 24860 698 24860 {lab=u_cas_int_out_int2_b14}
C {./lab_pin.sym} 698 24860 0 0 {name=l1322_0 lab=u_cas_int_out_int2_b14}
N 718 24880 698 24880 {lab=out_cas_int_b14}
C {./lab_pin.sym} 698 24880 0 0 {name=l1322_1 lab=out_cas_int_b14}
N 718 24900 698 24900 {lab=u_cas_int_out_int2_b15}
C {./lab_pin.sym} 698 24900 0 0 {name=l1322_2 lab=u_cas_int_out_int2_b15}
N 718 24920 698 24920 {lab=out_cas_int_b15}
C {./lab_pin.sym} 698 24920 0 0 {name=l1322_3 lab=out_cas_int_b15}
N 718 24940 698 24940 {lab=n_0686}
C {./lab_pin.sym} 698 24940 0 0 {name=l1322_4 lab=n_0686}
N 902 24870 922 24870 {lab=VDD}
C {./lab_pin.sym} 922 24870 0 1 {name=l1322_5 lab=VDD}
N 902 24890 922 24890 {lab=VDD}
C {./lab_pin.sym} 922 24890 0 1 {name=l1322_6 lab=VDD}
N 902 24910 922 24910 {lab=VSS}
C {./lab_pin.sym} 922 24910 0 1 {name=l1322_7 lab=VSS}
N 902 24930 922 24930 {lab=VSS}
C {./lab_pin.sym} 922 24930 0 1 {name=l1322_8 lab=VSS}
C {./aoi21_1.sym} 1215 24900 0 0 {name=Xn_1264}
N 1123 24870 1103 24870 {lab=n_0674}
C {./lab_pin.sym} 1103 24870 0 0 {name=l1323_0 lab=n_0674}
N 1123 24890 1103 24890 {lab=n_0678}
C {./lab_pin.sym} 1103 24890 0 0 {name=l1323_1 lab=n_0678}
N 1123 24910 1103 24910 {lab=n_0676}
C {./lab_pin.sym} 1103 24910 0 0 {name=l1323_2 lab=n_0676}
N 1123 24930 1103 24930 {lab=n_0687}
C {./lab_pin.sym} 1103 24930 0 0 {name=l1323_3 lab=n_0687}
N 1307 24870 1327 24870 {lab=VDD}
C {./lab_pin.sym} 1327 24870 0 1 {name=l1323_4 lab=VDD}
N 1307 24890 1327 24890 {lab=VDD}
C {./lab_pin.sym} 1327 24890 0 1 {name=l1323_5 lab=VDD}
N 1307 24910 1327 24910 {lab=VSS}
C {./lab_pin.sym} 1327 24910 0 1 {name=l1323_6 lab=VSS}
N 1307 24930 1327 24930 {lab=VSS}
C {./lab_pin.sym} 1327 24930 0 1 {name=l1323_7 lab=VSS}
C {./and4_1.sym} 1620 24900 0 0 {name=Xn_1265}
N 1528 24860 1508 24860 {lab=n_0673}
C {./lab_pin.sym} 1508 24860 0 0 {name=l1324_0 lab=n_0673}
N 1528 24880 1508 24880 {lab=n_0674}
C {./lab_pin.sym} 1508 24880 0 0 {name=l1324_1 lab=n_0674}
N 1528 24900 1508 24900 {lab=n_0677}
C {./lab_pin.sym} 1508 24900 0 0 {name=l1324_2 lab=n_0677}
N 1528 24920 1508 24920 {lab=n_0678}
C {./lab_pin.sym} 1508 24920 0 0 {name=l1324_3 lab=n_0678}
N 1528 24940 1508 24940 {lab=n_0688}
C {./lab_pin.sym} 1508 24940 0 0 {name=l1324_4 lab=n_0688}
N 1712 24870 1732 24870 {lab=VDD}
C {./lab_pin.sym} 1732 24870 0 1 {name=l1324_5 lab=VDD}
N 1712 24890 1732 24890 {lab=VDD}
C {./lab_pin.sym} 1732 24890 0 1 {name=l1324_6 lab=VDD}
N 1712 24910 1732 24910 {lab=VSS}
C {./lab_pin.sym} 1732 24910 0 1 {name=l1324_7 lab=VSS}
N 1712 24930 1732 24930 {lab=VSS}
C {./lab_pin.sym} 1732 24930 0 1 {name=l1324_8 lab=VSS}
C {./nand4_1.sym} 2025 24900 0 0 {name=Xn_1266}
N 1933 24860 1913 24860 {lab=n_0673}
C {./lab_pin.sym} 1913 24860 0 0 {name=l1325_0 lab=n_0673}
N 1933 24880 1913 24880 {lab=n_0674}
C {./lab_pin.sym} 1913 24880 0 0 {name=l1325_1 lab=n_0674}
N 1933 24900 1913 24900 {lab=n_0677}
C {./lab_pin.sym} 1913 24900 0 0 {name=l1325_2 lab=n_0677}
N 1933 24920 1913 24920 {lab=n_0678}
C {./lab_pin.sym} 1913 24920 0 0 {name=l1325_3 lab=n_0678}
N 1933 24940 1913 24940 {lab=n_0689}
C {./lab_pin.sym} 1913 24940 0 0 {name=l1325_4 lab=n_0689}
N 2117 24870 2137 24870 {lab=VDD}
C {./lab_pin.sym} 2137 24870 0 1 {name=l1325_5 lab=VDD}
N 2117 24890 2137 24890 {lab=VDD}
C {./lab_pin.sym} 2137 24890 0 1 {name=l1325_6 lab=VDD}
N 2117 24910 2137 24910 {lab=VSS}
C {./lab_pin.sym} 2137 24910 0 1 {name=l1325_7 lab=VSS}
N 2117 24930 2137 24930 {lab=VSS}
C {./lab_pin.sym} 2137 24930 0 1 {name=l1325_8 lab=VSS}
C {./aoi22_1.sym} 2430 24900 0 0 {name=Xn_1267}
N 2338 24860 2318 24860 {lab=n_0645}
C {./lab_pin.sym} 2318 24860 0 0 {name=l1326_0 lab=n_0645}
N 2338 24880 2318 24880 {lab=n_0659}
C {./lab_pin.sym} 2318 24880 0 0 {name=l1326_1 lab=n_0659}
N 2338 24900 2318 24900 {lab=n_0656}
C {./lab_pin.sym} 2318 24900 0 0 {name=l1326_2 lab=n_0656}
N 2338 24920 2318 24920 {lab=n_0652}
C {./lab_pin.sym} 2318 24920 0 0 {name=l1326_3 lab=n_0652}
N 2338 24940 2318 24940 {lab=n_0690}
C {./lab_pin.sym} 2318 24940 0 0 {name=l1326_4 lab=n_0690}
N 2522 24870 2542 24870 {lab=VDD}
C {./lab_pin.sym} 2542 24870 0 1 {name=l1326_5 lab=VDD}
N 2522 24890 2542 24890 {lab=VDD}
C {./lab_pin.sym} 2542 24890 0 1 {name=l1326_6 lab=VDD}
N 2522 24910 2542 24910 {lab=VSS}
C {./lab_pin.sym} 2542 24910 0 1 {name=l1326_7 lab=VSS}
N 2522 24930 2542 24930 {lab=VSS}
C {./lab_pin.sym} 2542 24930 0 1 {name=l1326_8 lab=VSS}
C {./oai21_1.sym} 2835 24900 0 0 {name=Xn_1268}
N 2743 24870 2723 24870 {lab=n_0646}
C {./lab_pin.sym} 2723 24870 0 0 {name=l1327_0 lab=n_0646}
N 2743 24890 2723 24890 {lab=n_0660}
C {./lab_pin.sym} 2723 24890 0 0 {name=l1327_1 lab=n_0660}
N 2743 24910 2723 24910 {lab=n_0657}
C {./lab_pin.sym} 2723 24910 0 0 {name=l1327_2 lab=n_0657}
N 2743 24930 2723 24930 {lab=n_0691}
C {./lab_pin.sym} 2723 24930 0 0 {name=l1327_3 lab=n_0691}
N 2927 24870 2947 24870 {lab=VDD}
C {./lab_pin.sym} 2947 24870 0 1 {name=l1327_4 lab=VDD}
N 2927 24890 2947 24890 {lab=VDD}
C {./lab_pin.sym} 2947 24890 0 1 {name=l1327_5 lab=VDD}
N 2927 24910 2947 24910 {lab=VSS}
C {./lab_pin.sym} 2947 24910 0 1 {name=l1327_6 lab=VSS}
N 2927 24930 2947 24930 {lab=VSS}
C {./lab_pin.sym} 2947 24930 0 1 {name=l1327_7 lab=VSS}
C {./and2_1.sym} 3240 24900 0 0 {name=Xn_1269}
N 3148 24870 3128 24870 {lab=n_0668}
C {./lab_pin.sym} 3128 24870 0 0 {name=l1328_0 lab=n_0668}
N 3148 24890 3128 24890 {lab=n_0688}
C {./lab_pin.sym} 3128 24890 0 0 {name=l1328_1 lab=n_0688}
N 3148 24910 3128 24910 {lab=n_0692}
C {./lab_pin.sym} 3128 24910 0 0 {name=l1328_2 lab=n_0692}
N 3148 24930 3128 24930 {lab=VDD}
C {./lab_pin.sym} 3128 24930 0 0 {name=l1328_3 lab=VDD}
N 3332 24880 3352 24880 {lab=VDD}
C {./lab_pin.sym} 3352 24880 0 1 {name=l1328_4 lab=VDD}
N 3332 24900 3352 24900 {lab=VSS}
C {./lab_pin.sym} 3352 24900 0 1 {name=l1328_5 lab=VSS}
N 3332 24920 3352 24920 {lab=VSS}
C {./lab_pin.sym} 3352 24920 0 1 {name=l1328_6 lab=VSS}
C {./nand2_1.sym} 3645 24900 0 0 {name=Xn_1270}
N 3553 24870 3533 24870 {lab=n_0668}
C {./lab_pin.sym} 3533 24870 0 0 {name=l1329_0 lab=n_0668}
N 3553 24890 3533 24890 {lab=n_0688}
C {./lab_pin.sym} 3533 24890 0 0 {name=l1329_1 lab=n_0688}
N 3553 24910 3533 24910 {lab=n_0693}
C {./lab_pin.sym} 3533 24910 0 0 {name=l1329_2 lab=n_0693}
N 3553 24930 3533 24930 {lab=VDD}
C {./lab_pin.sym} 3533 24930 0 0 {name=l1329_3 lab=VDD}
N 3737 24880 3757 24880 {lab=VDD}
C {./lab_pin.sym} 3757 24880 0 1 {name=l1329_4 lab=VDD}
N 3737 24900 3757 24900 {lab=VSS}
C {./lab_pin.sym} 3757 24900 0 1 {name=l1329_5 lab=VSS}
N 3737 24920 3757 24920 {lab=VSS}
C {./lab_pin.sym} 3757 24920 0 1 {name=l1329_6 lab=VSS}
C {./aoi21_1.sym} 4050 24900 0 0 {name=Xn_1271}
N 3958 24870 3938 24870 {lab=n_0670}
C {./lab_pin.sym} 3938 24870 0 0 {name=l1330_0 lab=n_0670}
N 3958 24890 3938 24890 {lab=n_0688}
C {./lab_pin.sym} 3938 24890 0 0 {name=l1330_1 lab=n_0688}
N 3958 24910 3938 24910 {lab=n_0687}
C {./lab_pin.sym} 3938 24910 0 0 {name=l1330_2 lab=n_0687}
N 3958 24930 3938 24930 {lab=n_0694}
C {./lab_pin.sym} 3938 24930 0 0 {name=l1330_3 lab=n_0694}
N 4142 24870 4162 24870 {lab=VDD}
C {./lab_pin.sym} 4162 24870 0 1 {name=l1330_4 lab=VDD}
N 4142 24890 4162 24890 {lab=VDD}
C {./lab_pin.sym} 4162 24890 0 1 {name=l1330_5 lab=VDD}
N 4142 24910 4162 24910 {lab=VSS}
C {./lab_pin.sym} 4162 24910 0 1 {name=l1330_6 lab=VSS}
N 4142 24930 4162 24930 {lab=VSS}
C {./lab_pin.sym} 4162 24930 0 1 {name=l1330_7 lab=VSS}
C {./oai22_1.sym} 4455 24900 0 0 {name=Xn_1272}
N 4363 24860 4343 24860 {lab=n_0671}
C {./lab_pin.sym} 4343 24860 0 0 {name=l1331_0 lab=n_0671}
N 4363 24880 4343 24880 {lab=n_0689}
C {./lab_pin.sym} 4343 24880 0 0 {name=l1331_1 lab=n_0689}
N 4363 24900 4343 24900 {lab=n_0686}
C {./lab_pin.sym} 4343 24900 0 0 {name=l1331_2 lab=n_0686}
N 4363 24920 4343 24920 {lab=n_0676}
C {./lab_pin.sym} 4343 24920 0 0 {name=l1331_3 lab=n_0676}
N 4363 24940 4343 24940 {lab=n_0695}
C {./lab_pin.sym} 4343 24940 0 0 {name=l1331_4 lab=n_0695}
N 4547 24870 4567 24870 {lab=VDD}
C {./lab_pin.sym} 4567 24870 0 1 {name=l1331_5 lab=VDD}
N 4547 24890 4567 24890 {lab=VDD}
C {./lab_pin.sym} 4567 24890 0 1 {name=l1331_6 lab=VDD}
N 4547 24910 4567 24910 {lab=VSS}
C {./lab_pin.sym} 4567 24910 0 1 {name=l1331_7 lab=VSS}
N 4547 24930 4567 24930 {lab=VSS}
C {./lab_pin.sym} 4567 24930 0 1 {name=l1331_8 lab=VSS}
C {./aoi21_1.sym} 0 25125 0 0 {name=Xn_1273}
N -92 25095 -112 25095 {lab=n_0691}
C {./lab_pin.sym} -112 25095 0 0 {name=l1332_0 lab=n_0691}
N -92 25115 -112 25115 {lab=n_0692}
C {./lab_pin.sym} -112 25115 0 0 {name=l1332_1 lab=n_0692}
N -92 25135 -112 25135 {lab=n_0695}
C {./lab_pin.sym} -112 25135 0 0 {name=l1332_2 lab=n_0695}
N -92 25155 -112 25155 {lab=n_0696}
C {./lab_pin.sym} -112 25155 0 0 {name=l1332_3 lab=n_0696}
N 92 25095 112 25095 {lab=VDD}
C {./lab_pin.sym} 112 25095 0 1 {name=l1332_4 lab=VDD}
N 92 25115 112 25115 {lab=VDD}
C {./lab_pin.sym} 112 25115 0 1 {name=l1332_5 lab=VDD}
N 92 25135 112 25135 {lab=VSS}
C {./lab_pin.sym} 112 25135 0 1 {name=l1332_6 lab=VSS}
N 92 25155 112 25155 {lab=VSS}
C {./lab_pin.sym} 112 25155 0 1 {name=l1332_7 lab=VSS}
C {./oai21_1.sym} 405 25125 0 0 {name=Xn_1274}
N 313 25095 293 25095 {lab=n_0690}
C {./lab_pin.sym} 293 25095 0 0 {name=l1333_0 lab=n_0690}
N 313 25115 293 25115 {lab=n_0693}
C {./lab_pin.sym} 293 25115 0 0 {name=l1333_1 lab=n_0693}
N 313 25135 293 25135 {lab=n_0694}
C {./lab_pin.sym} 293 25135 0 0 {name=l1333_2 lab=n_0694}
N 313 25155 293 25155 {lab=n_0697}
C {./lab_pin.sym} 293 25155 0 0 {name=l1333_3 lab=n_0697}
N 497 25095 517 25095 {lab=VDD}
C {./lab_pin.sym} 517 25095 0 1 {name=l1333_4 lab=VDD}
N 497 25115 517 25115 {lab=VDD}
C {./lab_pin.sym} 517 25115 0 1 {name=l1333_5 lab=VDD}
N 497 25135 517 25135 {lab=VSS}
C {./lab_pin.sym} 517 25135 0 1 {name=l1333_6 lab=VSS}
N 497 25155 517 25155 {lab=VSS}
C {./lab_pin.sym} 517 25155 0 1 {name=l1333_7 lab=VSS}
C {./and4_1.sym} 810 25125 0 0 {name=Xn_1275}
N 718 25085 698 25085 {lab=n_0643}
C {./lab_pin.sym} 698 25085 0 0 {name=l1334_0 lab=n_0643}
N 718 25105 698 25105 {lab=n_0659}
C {./lab_pin.sym} 698 25105 0 0 {name=l1334_1 lab=n_0659}
N 718 25125 698 25125 {lab=n_0668}
C {./lab_pin.sym} 698 25125 0 0 {name=l1334_2 lab=n_0668}
N 718 25145 698 25145 {lab=n_0688}
C {./lab_pin.sym} 698 25145 0 0 {name=l1334_3 lab=n_0688}
N 718 25165 698 25165 {lab=n_0698}
C {./lab_pin.sym} 698 25165 0 0 {name=l1334_4 lab=n_0698}
N 902 25095 922 25095 {lab=VDD}
C {./lab_pin.sym} 922 25095 0 1 {name=l1334_5 lab=VDD}
N 902 25115 922 25115 {lab=VDD}
C {./lab_pin.sym} 922 25115 0 1 {name=l1334_6 lab=VDD}
N 902 25135 922 25135 {lab=VSS}
C {./lab_pin.sym} 922 25135 0 1 {name=l1334_7 lab=VSS}
N 902 25155 922 25155 {lab=VSS}
C {./lab_pin.sym} 922 25155 0 1 {name=l1334_8 lab=VSS}
C {./nand4_1.sym} 1215 25125 0 0 {name=Xn_1276}
N 1123 25085 1103 25085 {lab=n_0643}
C {./lab_pin.sym} 1103 25085 0 0 {name=l1335_0 lab=n_0643}
N 1123 25105 1103 25105 {lab=n_0659}
C {./lab_pin.sym} 1103 25105 0 0 {name=l1335_1 lab=n_0659}
N 1123 25125 1103 25125 {lab=n_0668}
C {./lab_pin.sym} 1103 25125 0 0 {name=l1335_2 lab=n_0668}
N 1123 25145 1103 25145 {lab=n_0688}
C {./lab_pin.sym} 1103 25145 0 0 {name=l1335_3 lab=n_0688}
N 1123 25165 1103 25165 {lab=n_0699}
C {./lab_pin.sym} 1103 25165 0 0 {name=l1335_4 lab=n_0699}
N 1307 25095 1327 25095 {lab=VDD}
C {./lab_pin.sym} 1327 25095 0 1 {name=l1335_5 lab=VDD}
N 1307 25115 1327 25115 {lab=VDD}
C {./lab_pin.sym} 1327 25115 0 1 {name=l1335_6 lab=VDD}
N 1307 25135 1327 25135 {lab=VSS}
C {./lab_pin.sym} 1327 25135 0 1 {name=l1335_7 lab=VSS}
N 1307 25155 1327 25155 {lab=VSS}
C {./lab_pin.sym} 1327 25155 0 1 {name=l1335_8 lab=VSS}
C {./aoi21_1.sym} 1620 25125 0 0 {name=Xn_1277}
N 1528 25095 1508 25095 {lab=n_0636}
C {./lab_pin.sym} 1508 25095 0 0 {name=l1336_0 lab=n_0636}
N 1528 25115 1508 25115 {lab=n_0698}
C {./lab_pin.sym} 1508 25115 0 0 {name=l1336_1 lab=n_0698}
N 1528 25135 1508 25135 {lab=n_0697}
C {./lab_pin.sym} 1508 25135 0 0 {name=l1336_2 lab=n_0697}
N 1528 25155 1508 25155 {lab=n_0700}
C {./lab_pin.sym} 1508 25155 0 0 {name=l1336_3 lab=n_0700}
N 1712 25095 1732 25095 {lab=VDD}
C {./lab_pin.sym} 1732 25095 0 1 {name=l1336_4 lab=VDD}
N 1712 25115 1732 25115 {lab=VDD}
C {./lab_pin.sym} 1732 25115 0 1 {name=l1336_5 lab=VDD}
N 1712 25135 1732 25135 {lab=VSS}
C {./lab_pin.sym} 1732 25135 0 1 {name=l1336_6 lab=VSS}
N 1712 25155 1732 25155 {lab=VSS}
C {./lab_pin.sym} 1732 25155 0 1 {name=l1336_7 lab=VSS}
C {./oai21_1.sym} 2025 25125 0 0 {name=Xn_1278}
N 1933 25095 1913 25095 {lab=n_0635}
C {./lab_pin.sym} 1913 25095 0 0 {name=l1337_0 lab=n_0635}
N 1933 25115 1913 25115 {lab=n_0699}
C {./lab_pin.sym} 1913 25115 0 0 {name=l1337_1 lab=n_0699}
N 1933 25135 1913 25135 {lab=n_0696}
C {./lab_pin.sym} 1913 25135 0 0 {name=l1337_2 lab=n_0696}
N 1933 25155 1913 25155 {lab=n_0701}
C {./lab_pin.sym} 1913 25155 0 0 {name=l1337_3 lab=n_0701}
N 2117 25095 2137 25095 {lab=VDD}
C {./lab_pin.sym} 2137 25095 0 1 {name=l1337_4 lab=VDD}
N 2117 25115 2137 25115 {lab=VDD}
C {./lab_pin.sym} 2137 25115 0 1 {name=l1337_5 lab=VDD}
N 2117 25135 2137 25135 {lab=VSS}
C {./lab_pin.sym} 2137 25135 0 1 {name=l1337_6 lab=VSS}
N 2117 25155 2137 25155 {lab=VSS}
C {./lab_pin.sym} 2137 25155 0 1 {name=l1337_7 lab=VSS}
C {./nand2_1.sym} 2430 25125 0 0 {name=Xn_1279}
N 2338 25095 2318 25095 {lab=n_0701}
C {./lab_pin.sym} 2318 25095 0 0 {name=l1338_0 lab=n_0701}
N 2338 25115 2318 25115 {lab=n_0685}
C {./lab_pin.sym} 2318 25115 0 0 {name=l1338_1 lab=n_0685}
N 2338 25135 2318 25135 {lab=n_0702}
C {./lab_pin.sym} 2318 25135 0 0 {name=l1338_2 lab=n_0702}
N 2338 25155 2318 25155 {lab=VDD}
C {./lab_pin.sym} 2318 25155 0 0 {name=l1338_3 lab=VDD}
N 2522 25105 2542 25105 {lab=VDD}
C {./lab_pin.sym} 2542 25105 0 1 {name=l1338_4 lab=VDD}
N 2522 25125 2542 25125 {lab=VSS}
C {./lab_pin.sym} 2542 25125 0 1 {name=l1338_5 lab=VSS}
N 2522 25145 2542 25145 {lab=VSS}
C {./lab_pin.sym} 2542 25145 0 1 {name=l1338_6 lab=VSS}
C {./xor2_1.sym} 2835 25125 0 0 {name=Xn_1280}
N 2743 25095 2723 25095 {lab=n_0685}
C {./lab_pin.sym} 2723 25095 0 0 {name=l1339_0 lab=n_0685}
N 2743 25115 2723 25115 {lab=n_0701}
C {./lab_pin.sym} 2723 25115 0 0 {name=l1339_1 lab=n_0701}
N 2743 25135 2723 25135 {lab=n_0119}
C {./lab_pin.sym} 2723 25135 0 0 {name=l1339_2 lab=n_0119}
N 2743 25155 2723 25155 {lab=VDD}
C {./lab_pin.sym} 2723 25155 0 0 {name=l1339_3 lab=VDD}
N 2927 25105 2947 25105 {lab=VDD}
C {./lab_pin.sym} 2947 25105 0 1 {name=l1339_4 lab=VDD}
N 2927 25125 2947 25125 {lab=VSS}
C {./lab_pin.sym} 2947 25125 0 1 {name=l1339_5 lab=VSS}
N 2927 25145 2947 25145 {lab=VSS}
C {./lab_pin.sym} 2947 25145 0 1 {name=l1339_6 lab=VSS}
C {./nand2_1.sym} 3240 25125 0 0 {name=Xn_1281}
N 3148 25095 3128 25095 {lab=n_0684}
C {./lab_pin.sym} 3128 25095 0 0 {name=l1340_0 lab=n_0684}
N 3148 25115 3128 25115 {lab=n_0702}
C {./lab_pin.sym} 3128 25115 0 0 {name=l1340_1 lab=n_0702}
N 3148 25135 3128 25135 {lab=n_0703}
C {./lab_pin.sym} 3128 25135 0 0 {name=l1340_2 lab=n_0703}
N 3148 25155 3128 25155 {lab=VDD}
C {./lab_pin.sym} 3128 25155 0 0 {name=l1340_3 lab=VDD}
N 3332 25105 3352 25105 {lab=VDD}
C {./lab_pin.sym} 3352 25105 0 1 {name=l1340_4 lab=VDD}
N 3332 25125 3352 25125 {lab=VSS}
C {./lab_pin.sym} 3352 25125 0 1 {name=l1340_5 lab=VSS}
N 3332 25145 3352 25145 {lab=VSS}
C {./lab_pin.sym} 3352 25145 0 1 {name=l1340_6 lab=VSS}
C {./nor2_1.sym} 3645 25125 0 0 {name=Xn_1282}
N 3553 25095 3533 25095 {lab=u_cas_int_out_int2_b17}
C {./lab_pin.sym} 3533 25095 0 0 {name=l1341_0 lab=u_cas_int_out_int2_b17}
N 3553 25115 3533 25115 {lab=out_cas_int_b17}
C {./lab_pin.sym} 3533 25115 0 0 {name=l1341_1 lab=out_cas_int_b17}
N 3553 25135 3533 25135 {lab=n_0704}
C {./lab_pin.sym} 3533 25135 0 0 {name=l1341_2 lab=n_0704}
N 3553 25155 3533 25155 {lab=VDD}
C {./lab_pin.sym} 3533 25155 0 0 {name=l1341_3 lab=VDD}
N 3737 25105 3757 25105 {lab=VDD}
C {./lab_pin.sym} 3757 25105 0 1 {name=l1341_4 lab=VDD}
N 3737 25125 3757 25125 {lab=VSS}
C {./lab_pin.sym} 3757 25125 0 1 {name=l1341_5 lab=VSS}
N 3737 25145 3757 25145 {lab=VSS}
C {./lab_pin.sym} 3757 25145 0 1 {name=l1341_6 lab=VSS}
C {./nand2_1.sym} 4050 25125 0 0 {name=Xn_1283}
N 3958 25095 3938 25095 {lab=u_cas_int_out_int2_b17}
C {./lab_pin.sym} 3938 25095 0 0 {name=l1342_0 lab=u_cas_int_out_int2_b17}
N 3958 25115 3938 25115 {lab=out_cas_int_b17}
C {./lab_pin.sym} 3938 25115 0 0 {name=l1342_1 lab=out_cas_int_b17}
N 3958 25135 3938 25135 {lab=n_0705}
C {./lab_pin.sym} 3938 25135 0 0 {name=l1342_2 lab=n_0705}
N 3958 25155 3938 25155 {lab=VDD}
C {./lab_pin.sym} 3938 25155 0 0 {name=l1342_3 lab=VDD}
N 4142 25105 4162 25105 {lab=VDD}
C {./lab_pin.sym} 4162 25105 0 1 {name=l1342_4 lab=VDD}
N 4142 25125 4162 25125 {lab=VSS}
C {./lab_pin.sym} 4162 25125 0 1 {name=l1342_5 lab=VSS}
N 4142 25145 4162 25145 {lab=VSS}
C {./lab_pin.sym} 4162 25145 0 1 {name=l1342_6 lab=VSS}
C {./xor2_1.sym} 4455 25125 0 0 {name=Xn_1284}
N 4363 25095 4343 25095 {lab=u_cas_int_out_int2_b17}
C {./lab_pin.sym} 4343 25095 0 0 {name=l1343_0 lab=u_cas_int_out_int2_b17}
N 4363 25115 4343 25115 {lab=out_cas_int_b17}
C {./lab_pin.sym} 4343 25115 0 0 {name=l1343_1 lab=out_cas_int_b17}
N 4363 25135 4343 25135 {lab=n_0706}
C {./lab_pin.sym} 4343 25135 0 0 {name=l1343_2 lab=n_0706}
N 4363 25155 4343 25155 {lab=VDD}
C {./lab_pin.sym} 4343 25155 0 0 {name=l1343_3 lab=VDD}
N 4547 25105 4567 25105 {lab=VDD}
C {./lab_pin.sym} 4567 25105 0 1 {name=l1343_4 lab=VDD}
N 4547 25125 4567 25125 {lab=VSS}
C {./lab_pin.sym} 4567 25125 0 1 {name=l1343_5 lab=VSS}
N 4547 25145 4567 25145 {lab=VSS}
C {./lab_pin.sym} 4567 25145 0 1 {name=l1343_6 lab=VSS}
C {./xor2_1.sym} 0 25350 0 0 {name=Xn_1285}
N -92 25320 -112 25320 {lab=n_0703}
C {./lab_pin.sym} -112 25320 0 0 {name=l1344_0 lab=n_0703}
N -92 25340 -112 25340 {lab=n_0706}
C {./lab_pin.sym} -112 25340 0 0 {name=l1344_1 lab=n_0706}
N -92 25360 -112 25360 {lab=n_0120}
C {./lab_pin.sym} -112 25360 0 0 {name=l1344_2 lab=n_0120}
N -92 25380 -112 25380 {lab=VDD}
C {./lab_pin.sym} -112 25380 0 0 {name=l1344_3 lab=VDD}
N 92 25330 112 25330 {lab=VDD}
C {./lab_pin.sym} 112 25330 0 1 {name=l1344_4 lab=VDD}
N 92 25350 112 25350 {lab=VSS}
C {./lab_pin.sym} 112 25350 0 1 {name=l1344_5 lab=VSS}
N 92 25370 112 25370 {lab=VSS}
C {./lab_pin.sym} 112 25370 0 1 {name=l1344_6 lab=VSS}
C {./or2_1.sym} 405 25350 0 0 {name=Xn_1286}
N 313 25320 293 25320 {lab=u_cas_int_out_int2_b18}
C {./lab_pin.sym} 293 25320 0 0 {name=l1345_0 lab=u_cas_int_out_int2_b18}
N 313 25340 293 25340 {lab=out_cas_int_b18}
C {./lab_pin.sym} 293 25340 0 0 {name=l1345_1 lab=out_cas_int_b18}
N 313 25360 293 25360 {lab=n_0707}
C {./lab_pin.sym} 293 25360 0 0 {name=l1345_2 lab=n_0707}
N 313 25380 293 25380 {lab=VDD}
C {./lab_pin.sym} 293 25380 0 0 {name=l1345_3 lab=VDD}
N 497 25330 517 25330 {lab=VDD}
C {./lab_pin.sym} 517 25330 0 1 {name=l1345_4 lab=VDD}
N 497 25350 517 25350 {lab=VSS}
C {./lab_pin.sym} 517 25350 0 1 {name=l1345_5 lab=VSS}
N 497 25370 517 25370 {lab=VSS}
C {./lab_pin.sym} 517 25370 0 1 {name=l1345_6 lab=VSS}
C {./nand2_1.sym} 810 25350 0 0 {name=Xn_1287}
N 718 25320 698 25320 {lab=u_cas_int_out_int2_b18}
C {./lab_pin.sym} 698 25320 0 0 {name=l1346_0 lab=u_cas_int_out_int2_b18}
N 718 25340 698 25340 {lab=out_cas_int_b18}
C {./lab_pin.sym} 698 25340 0 0 {name=l1346_1 lab=out_cas_int_b18}
N 718 25360 698 25360 {lab=n_0708}
C {./lab_pin.sym} 698 25360 0 0 {name=l1346_2 lab=n_0708}
N 718 25380 698 25380 {lab=VDD}
C {./lab_pin.sym} 698 25380 0 0 {name=l1346_3 lab=VDD}
N 902 25330 922 25330 {lab=VDD}
C {./lab_pin.sym} 922 25330 0 1 {name=l1346_4 lab=VDD}
N 902 25350 922 25350 {lab=VSS}
C {./lab_pin.sym} 922 25350 0 1 {name=l1346_5 lab=VSS}
N 902 25370 922 25370 {lab=VSS}
C {./lab_pin.sym} 922 25370 0 1 {name=l1346_6 lab=VSS}
C {./nand2_1.sym} 1215 25350 0 0 {name=Xn_1288}
N 1123 25320 1103 25320 {lab=n_0707}
C {./lab_pin.sym} 1103 25320 0 0 {name=l1347_0 lab=n_0707}
N 1123 25340 1103 25340 {lab=n_0708}
C {./lab_pin.sym} 1103 25340 0 0 {name=l1347_1 lab=n_0708}
N 1123 25360 1103 25360 {lab=n_0709}
C {./lab_pin.sym} 1103 25360 0 0 {name=l1347_2 lab=n_0709}
N 1123 25380 1103 25380 {lab=VDD}
C {./lab_pin.sym} 1103 25380 0 0 {name=l1347_3 lab=VDD}
N 1307 25330 1327 25330 {lab=VDD}
C {./lab_pin.sym} 1327 25330 0 1 {name=l1347_4 lab=VDD}
N 1307 25350 1327 25350 {lab=VSS}
C {./lab_pin.sym} 1327 25350 0 1 {name=l1347_5 lab=VSS}
N 1307 25370 1327 25370 {lab=VSS}
C {./lab_pin.sym} 1327 25370 0 1 {name=l1347_6 lab=VSS}
C {./aoi21_1.sym} 1620 25350 0 0 {name=Xn_1289}
N 1528 25320 1508 25320 {lab=n_0684}
C {./lab_pin.sym} 1508 25320 0 0 {name=l1348_0 lab=n_0684}
N 1528 25340 1508 25340 {lab=n_0705}
C {./lab_pin.sym} 1508 25340 0 0 {name=l1348_1 lab=n_0705}
N 1528 25360 1508 25360 {lab=n_0704}
C {./lab_pin.sym} 1508 25360 0 0 {name=l1348_2 lab=n_0704}
N 1528 25380 1508 25380 {lab=n_0710}
C {./lab_pin.sym} 1508 25380 0 0 {name=l1348_3 lab=n_0710}
N 1712 25320 1732 25320 {lab=VDD}
C {./lab_pin.sym} 1732 25320 0 1 {name=l1348_4 lab=VDD}
N 1712 25340 1732 25340 {lab=VDD}
C {./lab_pin.sym} 1732 25340 0 1 {name=l1348_5 lab=VDD}
N 1712 25360 1732 25360 {lab=VSS}
C {./lab_pin.sym} 1732 25360 0 1 {name=l1348_6 lab=VSS}
N 1712 25380 1732 25380 {lab=VSS}
C {./lab_pin.sym} 1732 25380 0 1 {name=l1348_7 lab=VSS}
C {./and2_1.sym} 2025 25350 0 0 {name=Xn_1290}
N 1933 25320 1913 25320 {lab=n_0685}
C {./lab_pin.sym} 1913 25320 0 0 {name=l1349_0 lab=n_0685}
N 1933 25340 1913 25340 {lab=n_0706}
C {./lab_pin.sym} 1913 25340 0 0 {name=l1349_1 lab=n_0706}
N 1933 25360 1913 25360 {lab=n_0711}
C {./lab_pin.sym} 1913 25360 0 0 {name=l1349_2 lab=n_0711}
N 1933 25380 1913 25380 {lab=VDD}
C {./lab_pin.sym} 1913 25380 0 0 {name=l1349_3 lab=VDD}
N 2117 25330 2137 25330 {lab=VDD}
C {./lab_pin.sym} 2137 25330 0 1 {name=l1349_4 lab=VDD}
N 2117 25350 2137 25350 {lab=VSS}
C {./lab_pin.sym} 2137 25350 0 1 {name=l1349_5 lab=VSS}
N 2117 25370 2137 25370 {lab=VSS}
C {./lab_pin.sym} 2137 25370 0 1 {name=l1349_6 lab=VSS}
C {./aoi21_1.sym} 2430 25350 0 0 {name=Xn_1291}
N 2338 25320 2318 25320 {lab=n_0701}
C {./lab_pin.sym} 2318 25320 0 0 {name=l1350_0 lab=n_0701}
N 2338 25340 2318 25340 {lab=n_0711}
C {./lab_pin.sym} 2318 25340 0 0 {name=l1350_1 lab=n_0711}
N 2338 25360 2318 25360 {lab=n_0710}
C {./lab_pin.sym} 2318 25360 0 0 {name=l1350_2 lab=n_0710}
N 2338 25380 2318 25380 {lab=n_0712}
C {./lab_pin.sym} 2318 25380 0 0 {name=l1350_3 lab=n_0712}
N 2522 25320 2542 25320 {lab=VDD}
C {./lab_pin.sym} 2542 25320 0 1 {name=l1350_4 lab=VDD}
N 2522 25340 2542 25340 {lab=VDD}
C {./lab_pin.sym} 2542 25340 0 1 {name=l1350_5 lab=VDD}
N 2522 25360 2542 25360 {lab=VSS}
C {./lab_pin.sym} 2542 25360 0 1 {name=l1350_6 lab=VSS}
N 2522 25380 2542 25380 {lab=VSS}
C {./lab_pin.sym} 2542 25380 0 1 {name=l1350_7 lab=VSS}
C {./xor2_1.sym} 2835 25350 0 0 {name=Xn_1292}
N 2743 25320 2723 25320 {lab=n_0709}
C {./lab_pin.sym} 2723 25320 0 0 {name=l1351_0 lab=n_0709}
N 2743 25340 2723 25340 {lab=n_0712}
C {./lab_pin.sym} 2723 25340 0 0 {name=l1351_1 lab=n_0712}
N 2743 25360 2723 25360 {lab=n_0121}
C {./lab_pin.sym} 2723 25360 0 0 {name=l1351_2 lab=n_0121}
N 2743 25380 2723 25380 {lab=VDD}
C {./lab_pin.sym} 2723 25380 0 0 {name=l1351_3 lab=VDD}
N 2927 25330 2947 25330 {lab=VDD}
C {./lab_pin.sym} 2947 25330 0 1 {name=l1351_4 lab=VDD}
N 2927 25350 2947 25350 {lab=VSS}
C {./lab_pin.sym} 2947 25350 0 1 {name=l1351_5 lab=VSS}
N 2927 25370 2947 25370 {lab=VSS}
C {./lab_pin.sym} 2947 25370 0 1 {name=l1351_6 lab=VSS}
C {./or2_1.sym} 3240 25350 0 0 {name=Xn_1293}
N 3148 25320 3128 25320 {lab=u_cas_int_out_int2_b19}
C {./lab_pin.sym} 3128 25320 0 0 {name=l1352_0 lab=u_cas_int_out_int2_b19}
N 3148 25340 3128 25340 {lab=out_cas_int_b19}
C {./lab_pin.sym} 3128 25340 0 0 {name=l1352_1 lab=out_cas_int_b19}
N 3148 25360 3128 25360 {lab=n_0713}
C {./lab_pin.sym} 3128 25360 0 0 {name=l1352_2 lab=n_0713}
N 3148 25380 3128 25380 {lab=VDD}
C {./lab_pin.sym} 3128 25380 0 0 {name=l1352_3 lab=VDD}
N 3332 25330 3352 25330 {lab=VDD}
C {./lab_pin.sym} 3352 25330 0 1 {name=l1352_4 lab=VDD}
N 3332 25350 3352 25350 {lab=VSS}
C {./lab_pin.sym} 3352 25350 0 1 {name=l1352_5 lab=VSS}
N 3332 25370 3352 25370 {lab=VSS}
C {./lab_pin.sym} 3352 25370 0 1 {name=l1352_6 lab=VSS}
C {./nand2_1.sym} 3645 25350 0 0 {name=Xn_1294}
N 3553 25320 3533 25320 {lab=u_cas_int_out_int2_b19}
C {./lab_pin.sym} 3533 25320 0 0 {name=l1353_0 lab=u_cas_int_out_int2_b19}
N 3553 25340 3533 25340 {lab=out_cas_int_b19}
C {./lab_pin.sym} 3533 25340 0 0 {name=l1353_1 lab=out_cas_int_b19}
N 3553 25360 3533 25360 {lab=n_0714}
C {./lab_pin.sym} 3533 25360 0 0 {name=l1353_2 lab=n_0714}
N 3553 25380 3533 25380 {lab=VDD}
C {./lab_pin.sym} 3533 25380 0 0 {name=l1353_3 lab=VDD}
N 3737 25330 3757 25330 {lab=VDD}
C {./lab_pin.sym} 3757 25330 0 1 {name=l1353_4 lab=VDD}
N 3737 25350 3757 25350 {lab=VSS}
C {./lab_pin.sym} 3757 25350 0 1 {name=l1353_5 lab=VSS}
N 3737 25370 3757 25370 {lab=VSS}
C {./lab_pin.sym} 3757 25370 0 1 {name=l1353_6 lab=VSS}
C {./oai21_1.sym} 4050 25350 0 0 {name=Xn_1295}
N 3958 25320 3938 25320 {lab=n_0709}
C {./lab_pin.sym} 3938 25320 0 0 {name=l1354_0 lab=n_0709}
N 3958 25340 3938 25340 {lab=n_0712}
C {./lab_pin.sym} 3938 25340 0 0 {name=l1354_1 lab=n_0712}
N 3958 25360 3938 25360 {lab=n_0708}
C {./lab_pin.sym} 3938 25360 0 0 {name=l1354_2 lab=n_0708}
N 3958 25380 3938 25380 {lab=n_0715}
C {./lab_pin.sym} 3938 25380 0 0 {name=l1354_3 lab=n_0715}
N 4142 25320 4162 25320 {lab=VDD}
C {./lab_pin.sym} 4162 25320 0 1 {name=l1354_4 lab=VDD}
N 4142 25340 4162 25340 {lab=VDD}
C {./lab_pin.sym} 4162 25340 0 1 {name=l1354_5 lab=VDD}
N 4142 25360 4162 25360 {lab=VSS}
C {./lab_pin.sym} 4162 25360 0 1 {name=l1354_6 lab=VSS}
N 4142 25380 4162 25380 {lab=VSS}
C {./lab_pin.sym} 4162 25380 0 1 {name=l1354_7 lab=VSS}
C {./xor3_1.sym} 4455 25350 0 0 {name=Xn_1296}
N 4363 25320 4343 25320 {lab=u_cas_int_out_int2_b19}
C {./lab_pin.sym} 4343 25320 0 0 {name=l1355_0 lab=u_cas_int_out_int2_b19}
N 4363 25340 4343 25340 {lab=out_cas_int_b19}
C {./lab_pin.sym} 4343 25340 0 0 {name=l1355_1 lab=out_cas_int_b19}
N 4363 25360 4343 25360 {lab=n_0715}
C {./lab_pin.sym} 4343 25360 0 0 {name=l1355_2 lab=n_0715}
N 4363 25380 4343 25380 {lab=n_0122}
C {./lab_pin.sym} 4343 25380 0 0 {name=l1355_3 lab=n_0122}
N 4547 25320 4567 25320 {lab=VDD}
C {./lab_pin.sym} 4567 25320 0 1 {name=l1355_4 lab=VDD}
N 4547 25340 4567 25340 {lab=VDD}
C {./lab_pin.sym} 4567 25340 0 1 {name=l1355_5 lab=VDD}
N 4547 25360 4567 25360 {lab=VSS}
C {./lab_pin.sym} 4567 25360 0 1 {name=l1355_6 lab=VSS}
N 4547 25380 4567 25380 {lab=VSS}
C {./lab_pin.sym} 4567 25380 0 1 {name=l1355_7 lab=VSS}
C {./and4_1.sym} 0 25575 0 0 {name=Xn_1297}
N -92 25535 -112 25535 {lab=n_0707}
C {./lab_pin.sym} -112 25535 0 0 {name=l1356_0 lab=n_0707}
N -92 25555 -112 25555 {lab=n_0708}
C {./lab_pin.sym} -112 25555 0 0 {name=l1356_1 lab=n_0708}
N -92 25575 -112 25575 {lab=n_0713}
C {./lab_pin.sym} -112 25575 0 0 {name=l1356_2 lab=n_0713}
N -92 25595 -112 25595 {lab=n_0714}
C {./lab_pin.sym} -112 25595 0 0 {name=l1356_3 lab=n_0714}
N -92 25615 -112 25615 {lab=n_0716}
C {./lab_pin.sym} -112 25615 0 0 {name=l1356_4 lab=n_0716}
N 92 25545 112 25545 {lab=VDD}
C {./lab_pin.sym} 112 25545 0 1 {name=l1356_5 lab=VDD}
N 92 25565 112 25565 {lab=VDD}
C {./lab_pin.sym} 112 25565 0 1 {name=l1356_6 lab=VDD}
N 92 25585 112 25585 {lab=VSS}
C {./lab_pin.sym} 112 25585 0 1 {name=l1356_7 lab=VSS}
N 92 25605 112 25605 {lab=VSS}
C {./lab_pin.sym} 112 25605 0 1 {name=l1356_8 lab=VSS}
C {./and3_1.sym} 405 25575 0 0 {name=Xn_1298}
N 313 25545 293 25545 {lab=n_0685}
C {./lab_pin.sym} 293 25545 0 0 {name=l1357_0 lab=n_0685}
N 313 25565 293 25565 {lab=n_0706}
C {./lab_pin.sym} 293 25565 0 0 {name=l1357_1 lab=n_0706}
N 313 25585 293 25585 {lab=n_0716}
C {./lab_pin.sym} 293 25585 0 0 {name=l1357_2 lab=n_0716}
N 313 25605 293 25605 {lab=n_0717}
C {./lab_pin.sym} 293 25605 0 0 {name=l1357_3 lab=n_0717}
N 497 25545 517 25545 {lab=VDD}
C {./lab_pin.sym} 517 25545 0 1 {name=l1357_4 lab=VDD}
N 497 25565 517 25565 {lab=VDD}
C {./lab_pin.sym} 517 25565 0 1 {name=l1357_5 lab=VDD}
N 497 25585 517 25585 {lab=VSS}
C {./lab_pin.sym} 517 25585 0 1 {name=l1357_6 lab=VSS}
N 497 25605 517 25605 {lab=VSS}
C {./lab_pin.sym} 517 25605 0 1 {name=l1357_7 lab=VSS}
C {./nand3_1.sym} 810 25575 0 0 {name=Xn_1299}
N 718 25545 698 25545 {lab=n_0685}
C {./lab_pin.sym} 698 25545 0 0 {name=l1358_0 lab=n_0685}
N 718 25565 698 25565 {lab=n_0706}
C {./lab_pin.sym} 698 25565 0 0 {name=l1358_1 lab=n_0706}
N 718 25585 698 25585 {lab=n_0716}
C {./lab_pin.sym} 698 25585 0 0 {name=l1358_2 lab=n_0716}
N 718 25605 698 25605 {lab=n_0718}
C {./lab_pin.sym} 698 25605 0 0 {name=l1358_3 lab=n_0718}
N 902 25545 922 25545 {lab=VDD}
C {./lab_pin.sym} 922 25545 0 1 {name=l1358_4 lab=VDD}
N 902 25565 922 25565 {lab=VDD}
C {./lab_pin.sym} 922 25565 0 1 {name=l1358_5 lab=VDD}
N 902 25585 922 25585 {lab=VSS}
C {./lab_pin.sym} 922 25585 0 1 {name=l1358_6 lab=VSS}
N 902 25605 922 25605 {lab=VSS}
C {./lab_pin.sym} 922 25605 0 1 {name=l1358_7 lab=VSS}
C {./nand2_1.sym} 1215 25575 0 0 {name=Xn_1300}
N 1123 25545 1103 25545 {lab=n_0710}
C {./lab_pin.sym} 1103 25545 0 0 {name=l1359_0 lab=n_0710}
N 1123 25565 1103 25565 {lab=n_0716}
C {./lab_pin.sym} 1103 25565 0 0 {name=l1359_1 lab=n_0716}
N 1123 25585 1103 25585 {lab=n_0719}
C {./lab_pin.sym} 1103 25585 0 0 {name=l1359_2 lab=n_0719}
N 1123 25605 1103 25605 {lab=VDD}
C {./lab_pin.sym} 1103 25605 0 0 {name=l1359_3 lab=VDD}
N 1307 25555 1327 25555 {lab=VDD}
C {./lab_pin.sym} 1327 25555 0 1 {name=l1359_4 lab=VDD}
N 1307 25575 1327 25575 {lab=VSS}
C {./lab_pin.sym} 1327 25575 0 1 {name=l1359_5 lab=VSS}
N 1307 25595 1327 25595 {lab=VSS}
C {./lab_pin.sym} 1327 25595 0 1 {name=l1359_6 lab=VSS}
C {./nand3_1.sym} 1620 25575 0 0 {name=Xn_1301}
N 1528 25545 1508 25545 {lab=n_0713}
C {./lab_pin.sym} 1508 25545 0 0 {name=l1360_0 lab=n_0713}
N 1528 25565 1508 25565 {lab=out_cas_int_b18}
C {./lab_pin.sym} 1508 25565 0 0 {name=l1360_1 lab=out_cas_int_b18}
N 1528 25585 1508 25585 {lab=u_cas_int_out_int2_b18}
C {./lab_pin.sym} 1508 25585 0 0 {name=l1360_2 lab=u_cas_int_out_int2_b18}
N 1528 25605 1508 25605 {lab=n_0720}
C {./lab_pin.sym} 1508 25605 0 0 {name=l1360_3 lab=n_0720}
N 1712 25545 1732 25545 {lab=VDD}
C {./lab_pin.sym} 1732 25545 0 1 {name=l1360_4 lab=VDD}
N 1712 25565 1732 25565 {lab=VDD}
C {./lab_pin.sym} 1732 25565 0 1 {name=l1360_5 lab=VDD}
N 1712 25585 1732 25585 {lab=VSS}
C {./lab_pin.sym} 1732 25585 0 1 {name=l1360_6 lab=VSS}
N 1712 25605 1732 25605 {lab=VSS}
C {./lab_pin.sym} 1732 25605 0 1 {name=l1360_7 lab=VSS}
C {./and3_1.sym} 2025 25575 0 0 {name=Xn_1302}
N 1933 25545 1913 25545 {lab=n_0714}
C {./lab_pin.sym} 1913 25545 0 0 {name=l1361_0 lab=n_0714}
N 1933 25565 1913 25565 {lab=n_0719}
C {./lab_pin.sym} 1913 25565 0 0 {name=l1361_1 lab=n_0719}
N 1933 25585 1913 25585 {lab=n_0720}
C {./lab_pin.sym} 1913 25585 0 0 {name=l1361_2 lab=n_0720}
N 1933 25605 1913 25605 {lab=n_0721}
C {./lab_pin.sym} 1913 25605 0 0 {name=l1361_3 lab=n_0721}
N 2117 25545 2137 25545 {lab=VDD}
C {./lab_pin.sym} 2137 25545 0 1 {name=l1361_4 lab=VDD}
N 2117 25565 2137 25565 {lab=VDD}
C {./lab_pin.sym} 2137 25565 0 1 {name=l1361_5 lab=VDD}
N 2117 25585 2137 25585 {lab=VSS}
C {./lab_pin.sym} 2137 25585 0 1 {name=l1361_6 lab=VSS}
N 2117 25605 2137 25605 {lab=VSS}
C {./lab_pin.sym} 2137 25605 0 1 {name=l1361_7 lab=VSS}
C {./nand3_1.sym} 2430 25575 0 0 {name=Xn_1303}
N 2338 25545 2318 25545 {lab=n_0714}
C {./lab_pin.sym} 2318 25545 0 0 {name=l1362_0 lab=n_0714}
N 2338 25565 2318 25565 {lab=n_0719}
C {./lab_pin.sym} 2318 25565 0 0 {name=l1362_1 lab=n_0719}
N 2338 25585 2318 25585 {lab=n_0720}
C {./lab_pin.sym} 2318 25585 0 0 {name=l1362_2 lab=n_0720}
N 2338 25605 2318 25605 {lab=n_0722}
C {./lab_pin.sym} 2318 25605 0 0 {name=l1362_3 lab=n_0722}
N 2522 25545 2542 25545 {lab=VDD}
C {./lab_pin.sym} 2542 25545 0 1 {name=l1362_4 lab=VDD}
N 2522 25565 2542 25565 {lab=VDD}
C {./lab_pin.sym} 2542 25565 0 1 {name=l1362_5 lab=VDD}
N 2522 25585 2542 25585 {lab=VSS}
C {./lab_pin.sym} 2542 25585 0 1 {name=l1362_6 lab=VSS}
N 2522 25605 2542 25605 {lab=VSS}
C {./lab_pin.sym} 2542 25605 0 1 {name=l1362_7 lab=VSS}
C {./aoi21_1.sym} 2835 25575 0 0 {name=Xn_1304}
N 2743 25545 2723 25545 {lab=n_0701}
C {./lab_pin.sym} 2723 25545 0 0 {name=l1363_0 lab=n_0701}
N 2743 25565 2723 25565 {lab=n_0717}
C {./lab_pin.sym} 2723 25565 0 0 {name=l1363_1 lab=n_0717}
N 2743 25585 2723 25585 {lab=n_0722}
C {./lab_pin.sym} 2723 25585 0 0 {name=l1363_2 lab=n_0722}
N 2743 25605 2723 25605 {lab=n_0723}
C {./lab_pin.sym} 2723 25605 0 0 {name=l1363_3 lab=n_0723}
N 2927 25545 2947 25545 {lab=VDD}
C {./lab_pin.sym} 2947 25545 0 1 {name=l1363_4 lab=VDD}
N 2927 25565 2947 25565 {lab=VDD}
C {./lab_pin.sym} 2947 25565 0 1 {name=l1363_5 lab=VDD}
N 2927 25585 2947 25585 {lab=VSS}
C {./lab_pin.sym} 2947 25585 0 1 {name=l1363_6 lab=VSS}
N 2927 25605 2947 25605 {lab=VSS}
C {./lab_pin.sym} 2947 25605 0 1 {name=l1363_7 lab=VSS}
C {./oai21_1.sym} 3240 25575 0 0 {name=Xn_1305}
N 3148 25545 3128 25545 {lab=n_0700}
C {./lab_pin.sym} 3128 25545 0 0 {name=l1364_0 lab=n_0700}
N 3148 25565 3128 25565 {lab=n_0718}
C {./lab_pin.sym} 3128 25565 0 0 {name=l1364_1 lab=n_0718}
N 3148 25585 3128 25585 {lab=n_0721}
C {./lab_pin.sym} 3128 25585 0 0 {name=l1364_2 lab=n_0721}
N 3148 25605 3128 25605 {lab=n_0724}
C {./lab_pin.sym} 3128 25605 0 0 {name=l1364_3 lab=n_0724}
N 3332 25545 3352 25545 {lab=VDD}
C {./lab_pin.sym} 3352 25545 0 1 {name=l1364_4 lab=VDD}
N 3332 25565 3352 25565 {lab=VDD}
C {./lab_pin.sym} 3352 25565 0 1 {name=l1364_5 lab=VDD}
N 3332 25585 3352 25585 {lab=VSS}
C {./lab_pin.sym} 3352 25585 0 1 {name=l1364_6 lab=VSS}
N 3332 25605 3352 25605 {lab=VSS}
C {./lab_pin.sym} 3352 25605 0 1 {name=l1364_7 lab=VSS}
C {./nor2_1.sym} 3645 25575 0 0 {name=Xn_1306}
N 3553 25545 3533 25545 {lab=u_cas_int_out_int2_b20}
C {./lab_pin.sym} 3533 25545 0 0 {name=l1365_0 lab=u_cas_int_out_int2_b20}
N 3553 25565 3533 25565 {lab=out_cas_int_b20}
C {./lab_pin.sym} 3533 25565 0 0 {name=l1365_1 lab=out_cas_int_b20}
N 3553 25585 3533 25585 {lab=n_0725}
C {./lab_pin.sym} 3533 25585 0 0 {name=l1365_2 lab=n_0725}
N 3553 25605 3533 25605 {lab=VDD}
C {./lab_pin.sym} 3533 25605 0 0 {name=l1365_3 lab=VDD}
N 3737 25555 3757 25555 {lab=VDD}
C {./lab_pin.sym} 3757 25555 0 1 {name=l1365_4 lab=VDD}
N 3737 25575 3757 25575 {lab=VSS}
C {./lab_pin.sym} 3757 25575 0 1 {name=l1365_5 lab=VSS}
N 3737 25595 3757 25595 {lab=VSS}
C {./lab_pin.sym} 3757 25595 0 1 {name=l1365_6 lab=VSS}
C {./and2_1.sym} 4050 25575 0 0 {name=Xn_1307}
N 3958 25545 3938 25545 {lab=u_cas_int_out_int2_b20}
C {./lab_pin.sym} 3938 25545 0 0 {name=l1366_0 lab=u_cas_int_out_int2_b20}
N 3958 25565 3938 25565 {lab=out_cas_int_b20}
C {./lab_pin.sym} 3938 25565 0 0 {name=l1366_1 lab=out_cas_int_b20}
N 3958 25585 3938 25585 {lab=n_0726}
C {./lab_pin.sym} 3938 25585 0 0 {name=l1366_2 lab=n_0726}
N 3958 25605 3938 25605 {lab=VDD}
C {./lab_pin.sym} 3938 25605 0 0 {name=l1366_3 lab=VDD}
N 4142 25555 4162 25555 {lab=VDD}
C {./lab_pin.sym} 4162 25555 0 1 {name=l1366_4 lab=VDD}
N 4142 25575 4162 25575 {lab=VSS}
C {./lab_pin.sym} 4162 25575 0 1 {name=l1366_5 lab=VSS}
N 4142 25595 4162 25595 {lab=VSS}
C {./lab_pin.sym} 4162 25595 0 1 {name=l1366_6 lab=VSS}
C {./nor2_1.sym} 4455 25575 0 0 {name=Xn_1308}
N 4363 25545 4343 25545 {lab=n_0725}
C {./lab_pin.sym} 4343 25545 0 0 {name=l1367_0 lab=n_0725}
N 4363 25565 4343 25565 {lab=n_0726}
C {./lab_pin.sym} 4343 25565 0 0 {name=l1367_1 lab=n_0726}
N 4363 25585 4343 25585 {lab=n_0727}
C {./lab_pin.sym} 4343 25585 0 0 {name=l1367_2 lab=n_0727}
N 4363 25605 4343 25605 {lab=VDD}
C {./lab_pin.sym} 4343 25605 0 0 {name=l1367_3 lab=VDD}
N 4547 25555 4567 25555 {lab=VDD}
C {./lab_pin.sym} 4567 25555 0 1 {name=l1367_4 lab=VDD}
N 4547 25575 4567 25575 {lab=VSS}
C {./lab_pin.sym} 4567 25575 0 1 {name=l1367_5 lab=VSS}
N 4547 25595 4567 25595 {lab=VSS}
C {./lab_pin.sym} 4567 25595 0 1 {name=l1367_6 lab=VSS}
C {./xor2_1.sym} 0 25800 0 0 {name=Xn_1309}
N -92 25770 -112 25770 {lab=n_0724}
C {./lab_pin.sym} -112 25770 0 0 {name=l1368_0 lab=n_0724}
N -92 25790 -112 25790 {lab=n_0727}
C {./lab_pin.sym} -112 25790 0 0 {name=l1368_1 lab=n_0727}
N -92 25810 -112 25810 {lab=n_0124}
C {./lab_pin.sym} -112 25810 0 0 {name=l1368_2 lab=n_0124}
N -92 25830 -112 25830 {lab=VDD}
C {./lab_pin.sym} -112 25830 0 0 {name=l1368_3 lab=VDD}
N 92 25780 112 25780 {lab=VDD}
C {./lab_pin.sym} 112 25780 0 1 {name=l1368_4 lab=VDD}
N 92 25800 112 25800 {lab=VSS}
C {./lab_pin.sym} 112 25800 0 1 {name=l1368_5 lab=VSS}
N 92 25820 112 25820 {lab=VSS}
C {./lab_pin.sym} 112 25820 0 1 {name=l1368_6 lab=VSS}
C {./aoi21_1.sym} 405 25800 0 0 {name=Xn_1310}
N 313 25770 293 25770 {lab=n_0724}
C {./lab_pin.sym} 293 25770 0 0 {name=l1369_0 lab=n_0724}
N 313 25790 293 25790 {lab=n_0727}
C {./lab_pin.sym} 293 25790 0 0 {name=l1369_1 lab=n_0727}
N 313 25810 293 25810 {lab=n_0726}
C {./lab_pin.sym} 293 25810 0 0 {name=l1369_2 lab=n_0726}
N 313 25830 293 25830 {lab=n_0728}
C {./lab_pin.sym} 293 25830 0 0 {name=l1369_3 lab=n_0728}
N 497 25770 517 25770 {lab=VDD}
C {./lab_pin.sym} 517 25770 0 1 {name=l1369_4 lab=VDD}
N 497 25790 517 25790 {lab=VDD}
C {./lab_pin.sym} 517 25790 0 1 {name=l1369_5 lab=VDD}
N 497 25810 517 25810 {lab=VSS}
C {./lab_pin.sym} 517 25810 0 1 {name=l1369_6 lab=VSS}
N 497 25830 517 25830 {lab=VSS}
C {./lab_pin.sym} 517 25830 0 1 {name=l1369_7 lab=VSS}
C {./or2_1.sym} 810 25800 0 0 {name=Xn_1311}
N 718 25770 698 25770 {lab=u_cas_int_out_int2_b21}
C {./lab_pin.sym} 698 25770 0 0 {name=l1370_0 lab=u_cas_int_out_int2_b21}
N 718 25790 698 25790 {lab=out_cas_int_b21}
C {./lab_pin.sym} 698 25790 0 0 {name=l1370_1 lab=out_cas_int_b21}
N 718 25810 698 25810 {lab=n_0729}
C {./lab_pin.sym} 698 25810 0 0 {name=l1370_2 lab=n_0729}
N 718 25830 698 25830 {lab=VDD}
C {./lab_pin.sym} 698 25830 0 0 {name=l1370_3 lab=VDD}
N 902 25780 922 25780 {lab=VDD}
C {./lab_pin.sym} 922 25780 0 1 {name=l1370_4 lab=VDD}
N 902 25800 922 25800 {lab=VSS}
C {./lab_pin.sym} 922 25800 0 1 {name=l1370_5 lab=VSS}
N 902 25820 922 25820 {lab=VSS}
C {./lab_pin.sym} 922 25820 0 1 {name=l1370_6 lab=VSS}
C {./nand2_1.sym} 1215 25800 0 0 {name=Xn_1312}
N 1123 25770 1103 25770 {lab=u_cas_int_out_int2_b21}
C {./lab_pin.sym} 1103 25770 0 0 {name=l1371_0 lab=u_cas_int_out_int2_b21}
N 1123 25790 1103 25790 {lab=out_cas_int_b21}
C {./lab_pin.sym} 1103 25790 0 0 {name=l1371_1 lab=out_cas_int_b21}
N 1123 25810 1103 25810 {lab=n_0730}
C {./lab_pin.sym} 1103 25810 0 0 {name=l1371_2 lab=n_0730}
N 1123 25830 1103 25830 {lab=VDD}
C {./lab_pin.sym} 1103 25830 0 0 {name=l1371_3 lab=VDD}
N 1307 25780 1327 25780 {lab=VDD}
C {./lab_pin.sym} 1327 25780 0 1 {name=l1371_4 lab=VDD}
N 1307 25800 1327 25800 {lab=VSS}
C {./lab_pin.sym} 1327 25800 0 1 {name=l1371_5 lab=VSS}
N 1307 25820 1327 25820 {lab=VSS}
C {./lab_pin.sym} 1327 25820 0 1 {name=l1371_6 lab=VSS}
C {./xnor3_1.sym} 1620 25800 0 0 {name=Xn_1313}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__xnor3_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -50 72 -50 {}
L 4 72 -50 72 50 {}
L 4 72 50 -72 50 {}
L 4 -72 50 -72 -50 {}
T {@name} -72 -70 0 0 0.33 0.33 {}
T {xnor3_1} -68 39 0 0 0.2 0.2 {}
L 4 -92 -30 -72 -30 {}
T {A1} -66 -35 0 0 0.16 0.16 {}
L 4 -92 -10 -72 -10 {}
T {A2} -66 -15 0 0 0.16 0.16 {}
L 4 -92 10 -72 10 {}
T {A3} -66 5 0 0 0.16 0.16 {}
L 4 -92 30 -72 30 {}
T {ZN} -66 25 0 0 0.16 0.16 {}
L 4 92 -30 72 -30 {}
T {VDD} 50.2 -35 0 0 0.16 0.16 {}
L 4 92 -10 72 -10 {}
T {VNW} 50.2 -15 0 0 0.16 0.16 {}
L 4 92 10 72 10 {}
T {VPW} 50.2 5 0 0 0.16 0.16 {}
L 4 92 30 72 30 {}
T {VSS} 50.2 25 0 0 0.16 0.16 {}
B 5 -94 -32 -90 -28 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -12 -90 -8 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 8 -90 12 {name=A3 dir=inout sim_pinnumber=3}
B 5 -94 28 -90 32 {name=ZN dir=inout sim_pinnumber=4}
B 5 90 -32 94 -28 {name=VDD dir=inout sim_pinnumber=5}
B 5 90 -12 94 -8 {name=VNW dir=inout sim_pinnumber=6}
B 5 90 8 94 12 {name=VPW dir=inout sim_pinnumber=7}
B 5 90 28 94 32 {name=VSS dir=inout sim_pinnumber=8}
]
N 1528 25770 1508 25770 {lab=u_cas_int_out_int2_b21}
C {./lab_pin.sym} 1508 25770 0 0 {name=l1372_0 lab=u_cas_int_out_int2_b21}
N 1528 25790 1508 25790 {lab=out_cas_int_b21}
C {./lab_pin.sym} 1508 25790 0 0 {name=l1372_1 lab=out_cas_int_b21}
N 1528 25810 1508 25810 {lab=n_0728}
C {./lab_pin.sym} 1508 25810 0 0 {name=l1372_2 lab=n_0728}
N 1528 25830 1508 25830 {lab=n_0125}
C {./lab_pin.sym} 1508 25830 0 0 {name=l1372_3 lab=n_0125}
N 1712 25770 1732 25770 {lab=VDD}
C {./lab_pin.sym} 1732 25770 0 1 {name=l1372_4 lab=VDD}
N 1712 25790 1732 25790 {lab=VDD}
C {./lab_pin.sym} 1732 25790 0 1 {name=l1372_5 lab=VDD}
N 1712 25810 1732 25810 {lab=VSS}
C {./lab_pin.sym} 1732 25810 0 1 {name=l1372_6 lab=VSS}
N 1712 25830 1732 25830 {lab=VSS}
C {./lab_pin.sym} 1732 25830 0 1 {name=l1372_7 lab=VSS}
C {./nand3_1.sym} 2025 25800 0 0 {name=Xn_1314}
N 1933 25770 1913 25770 {lab=n_0727}
C {./lab_pin.sym} 1913 25770 0 0 {name=l1373_0 lab=n_0727}
N 1933 25790 1913 25790 {lab=n_0729}
C {./lab_pin.sym} 1913 25790 0 0 {name=l1373_1 lab=n_0729}
N 1933 25810 1913 25810 {lab=n_0730}
C {./lab_pin.sym} 1913 25810 0 0 {name=l1373_2 lab=n_0730}
N 1933 25830 1913 25830 {lab=n_0731}
C {./lab_pin.sym} 1913 25830 0 0 {name=l1373_3 lab=n_0731}
N 2117 25770 2137 25770 {lab=VDD}
C {./lab_pin.sym} 2137 25770 0 1 {name=l1373_4 lab=VDD}
N 2117 25790 2137 25790 {lab=VDD}
C {./lab_pin.sym} 2137 25790 0 1 {name=l1373_5 lab=VDD}
N 2117 25810 2137 25810 {lab=VSS}
C {./lab_pin.sym} 2137 25810 0 1 {name=l1373_6 lab=VSS}
N 2117 25830 2137 25830 {lab=VSS}
C {./lab_pin.sym} 2137 25830 0 1 {name=l1373_7 lab=VSS}
C {./clkinv_1.sym} 2430 25800 0 0 {name=Xn_1315}
N 2338 25780 2318 25780 {lab=n_0731}
C {./lab_pin.sym} 2318 25780 0 0 {name=l1374_0 lab=n_0731}
N 2338 25800 2318 25800 {lab=n_0732}
C {./lab_pin.sym} 2318 25800 0 0 {name=l1374_1 lab=n_0732}
N 2338 25820 2318 25820 {lab=VDD}
C {./lab_pin.sym} 2318 25820 0 0 {name=l1374_2 lab=VDD}
N 2522 25780 2542 25780 {lab=VDD}
C {./lab_pin.sym} 2542 25780 0 1 {name=l1374_3 lab=VDD}
N 2522 25800 2542 25800 {lab=VSS}
C {./lab_pin.sym} 2542 25800 0 1 {name=l1374_4 lab=VSS}
N 2522 25820 2542 25820 {lab=VSS}
C {./lab_pin.sym} 2542 25820 0 1 {name=l1374_5 lab=VSS}
C {./nand3_1.sym} 2835 25800 0 0 {name=Xn_1316}
N 2743 25770 2723 25770 {lab=n_0729}
C {./lab_pin.sym} 2723 25770 0 0 {name=l1375_0 lab=n_0729}
N 2743 25790 2723 25790 {lab=out_cas_int_b20}
C {./lab_pin.sym} 2723 25790 0 0 {name=l1375_1 lab=out_cas_int_b20}
N 2743 25810 2723 25810 {lab=u_cas_int_out_int2_b20}
C {./lab_pin.sym} 2723 25810 0 0 {name=l1375_2 lab=u_cas_int_out_int2_b20}
N 2743 25830 2723 25830 {lab=n_0733}
C {./lab_pin.sym} 2723 25830 0 0 {name=l1375_3 lab=n_0733}
N 2927 25770 2947 25770 {lab=VDD}
C {./lab_pin.sym} 2947 25770 0 1 {name=l1375_4 lab=VDD}
N 2927 25790 2947 25790 {lab=VDD}
C {./lab_pin.sym} 2947 25790 0 1 {name=l1375_5 lab=VDD}
N 2927 25810 2947 25810 {lab=VSS}
C {./lab_pin.sym} 2947 25810 0 1 {name=l1375_6 lab=VSS}
N 2927 25830 2947 25830 {lab=VSS}
C {./lab_pin.sym} 2947 25830 0 1 {name=l1375_7 lab=VSS}
C {./and2_1.sym} 3240 25800 0 0 {name=Xn_1317}
N 3148 25770 3128 25770 {lab=n_0730}
C {./lab_pin.sym} 3128 25770 0 0 {name=l1376_0 lab=n_0730}
N 3148 25790 3128 25790 {lab=n_0733}
C {./lab_pin.sym} 3128 25790 0 0 {name=l1376_1 lab=n_0733}
N 3148 25810 3128 25810 {lab=n_0734}
C {./lab_pin.sym} 3128 25810 0 0 {name=l1376_2 lab=n_0734}
N 3148 25830 3128 25830 {lab=VDD}
C {./lab_pin.sym} 3128 25830 0 0 {name=l1376_3 lab=VDD}
N 3332 25780 3352 25780 {lab=VDD}
C {./lab_pin.sym} 3352 25780 0 1 {name=l1376_4 lab=VDD}
N 3332 25800 3352 25800 {lab=VSS}
C {./lab_pin.sym} 3352 25800 0 1 {name=l1376_5 lab=VSS}
N 3332 25820 3352 25820 {lab=VSS}
C {./lab_pin.sym} 3352 25820 0 1 {name=l1376_6 lab=VSS}
C {./nand2_1.sym} 3645 25800 0 0 {name=Xn_1318}
N 3553 25770 3533 25770 {lab=n_0730}
C {./lab_pin.sym} 3533 25770 0 0 {name=l1377_0 lab=n_0730}
N 3553 25790 3533 25790 {lab=n_0733}
C {./lab_pin.sym} 3533 25790 0 0 {name=l1377_1 lab=n_0733}
N 3553 25810 3533 25810 {lab=n_0735}
C {./lab_pin.sym} 3533 25810 0 0 {name=l1377_2 lab=n_0735}
N 3553 25830 3533 25830 {lab=VDD}
C {./lab_pin.sym} 3533 25830 0 0 {name=l1377_3 lab=VDD}
N 3737 25780 3757 25780 {lab=VDD}
C {./lab_pin.sym} 3757 25780 0 1 {name=l1377_4 lab=VDD}
N 3737 25800 3757 25800 {lab=VSS}
C {./lab_pin.sym} 3757 25800 0 1 {name=l1377_5 lab=VSS}
N 3737 25820 3757 25820 {lab=VSS}
C {./lab_pin.sym} 3757 25820 0 1 {name=l1377_6 lab=VSS}
C {./aoi21_1.sym} 4050 25800 0 0 {name=Xn_1319}
N 3958 25770 3938 25770 {lab=n_0724}
C {./lab_pin.sym} 3938 25770 0 0 {name=l1378_0 lab=n_0724}
N 3958 25790 3938 25790 {lab=n_0732}
C {./lab_pin.sym} 3938 25790 0 0 {name=l1378_1 lab=n_0732}
N 3958 25810 3938 25810 {lab=n_0735}
C {./lab_pin.sym} 3938 25810 0 0 {name=l1378_2 lab=n_0735}
N 3958 25830 3938 25830 {lab=n_0736}
C {./lab_pin.sym} 3938 25830 0 0 {name=l1378_3 lab=n_0736}
N 4142 25770 4162 25770 {lab=VDD}
C {./lab_pin.sym} 4162 25770 0 1 {name=l1378_4 lab=VDD}
N 4142 25790 4162 25790 {lab=VDD}
C {./lab_pin.sym} 4162 25790 0 1 {name=l1378_5 lab=VDD}
N 4142 25810 4162 25810 {lab=VSS}
C {./lab_pin.sym} 4162 25810 0 1 {name=l1378_6 lab=VSS}
N 4142 25830 4162 25830 {lab=VSS}
C {./lab_pin.sym} 4162 25830 0 1 {name=l1378_7 lab=VSS}
C {./oai21_1.sym} 4455 25800 0 0 {name=Xn_1320}
N 4363 25770 4343 25770 {lab=n_0723}
C {./lab_pin.sym} 4343 25770 0 0 {name=l1379_0 lab=n_0723}
N 4363 25790 4343 25790 {lab=n_0731}
C {./lab_pin.sym} 4343 25790 0 0 {name=l1379_1 lab=n_0731}
N 4363 25810 4343 25810 {lab=n_0734}
C {./lab_pin.sym} 4343 25810 0 0 {name=l1379_2 lab=n_0734}
N 4363 25830 4343 25830 {lab=n_0737}
C {./lab_pin.sym} 4343 25830 0 0 {name=l1379_3 lab=n_0737}
N 4547 25770 4567 25770 {lab=VDD}
C {./lab_pin.sym} 4567 25770 0 1 {name=l1379_4 lab=VDD}
N 4547 25790 4567 25790 {lab=VDD}
C {./lab_pin.sym} 4567 25790 0 1 {name=l1379_5 lab=VDD}
N 4547 25810 4567 25810 {lab=VSS}
C {./lab_pin.sym} 4567 25810 0 1 {name=l1379_6 lab=VSS}
N 4547 25830 4567 25830 {lab=VSS}
C {./lab_pin.sym} 4567 25830 0 1 {name=l1379_7 lab=VSS}
C {./nor2_1.sym} 0 26025 0 0 {name=Xn_1321}
N -92 25995 -112 25995 {lab=u_cas_int_out_int2_b22}
C {./lab_pin.sym} -112 25995 0 0 {name=l1380_0 lab=u_cas_int_out_int2_b22}
N -92 26015 -112 26015 {lab=out_cas_int_b22}
C {./lab_pin.sym} -112 26015 0 0 {name=l1380_1 lab=out_cas_int_b22}
N -92 26035 -112 26035 {lab=n_0738}
C {./lab_pin.sym} -112 26035 0 0 {name=l1380_2 lab=n_0738}
N -92 26055 -112 26055 {lab=VDD}
C {./lab_pin.sym} -112 26055 0 0 {name=l1380_3 lab=VDD}
N 92 26005 112 26005 {lab=VDD}
C {./lab_pin.sym} 112 26005 0 1 {name=l1380_4 lab=VDD}
N 92 26025 112 26025 {lab=VSS}
C {./lab_pin.sym} 112 26025 0 1 {name=l1380_5 lab=VSS}
N 92 26045 112 26045 {lab=VSS}
C {./lab_pin.sym} 112 26045 0 1 {name=l1380_6 lab=VSS}
C {./and2_1.sym} 405 26025 0 0 {name=Xn_1322}
N 313 25995 293 25995 {lab=u_cas_int_out_int2_b22}
C {./lab_pin.sym} 293 25995 0 0 {name=l1381_0 lab=u_cas_int_out_int2_b22}
N 313 26015 293 26015 {lab=out_cas_int_b22}
C {./lab_pin.sym} 293 26015 0 0 {name=l1381_1 lab=out_cas_int_b22}
N 313 26035 293 26035 {lab=n_0739}
C {./lab_pin.sym} 293 26035 0 0 {name=l1381_2 lab=n_0739}
N 313 26055 293 26055 {lab=VDD}
C {./lab_pin.sym} 293 26055 0 0 {name=l1381_3 lab=VDD}
N 497 26005 517 26005 {lab=VDD}
C {./lab_pin.sym} 517 26005 0 1 {name=l1381_4 lab=VDD}
N 497 26025 517 26025 {lab=VSS}
C {./lab_pin.sym} 517 26025 0 1 {name=l1381_5 lab=VSS}
N 497 26045 517 26045 {lab=VSS}
C {./lab_pin.sym} 517 26045 0 1 {name=l1381_6 lab=VSS}
C {./nand2_1.sym} 810 26025 0 0 {name=Xn_1323}
N 718 25995 698 25995 {lab=u_cas_int_out_int2_b22}
C {./lab_pin.sym} 698 25995 0 0 {name=l1382_0 lab=u_cas_int_out_int2_b22}
N 718 26015 698 26015 {lab=out_cas_int_b22}
C {./lab_pin.sym} 698 26015 0 0 {name=l1382_1 lab=out_cas_int_b22}
N 718 26035 698 26035 {lab=n_0740}
C {./lab_pin.sym} 698 26035 0 0 {name=l1382_2 lab=n_0740}
N 718 26055 698 26055 {lab=VDD}
C {./lab_pin.sym} 698 26055 0 0 {name=l1382_3 lab=VDD}
N 902 26005 922 26005 {lab=VDD}
C {./lab_pin.sym} 922 26005 0 1 {name=l1382_4 lab=VDD}
N 902 26025 922 26025 {lab=VSS}
C {./lab_pin.sym} 922 26025 0 1 {name=l1382_5 lab=VSS}
N 902 26045 922 26045 {lab=VSS}
C {./lab_pin.sym} 922 26045 0 1 {name=l1382_6 lab=VSS}
C {./xor3_1.sym} 1215 26025 0 0 {name=Xn_1324}
N 1123 25995 1103 25995 {lab=u_cas_int_out_int2_b22}
C {./lab_pin.sym} 1103 25995 0 0 {name=l1383_0 lab=u_cas_int_out_int2_b22}
N 1123 26015 1103 26015 {lab=out_cas_int_b22}
C {./lab_pin.sym} 1103 26015 0 0 {name=l1383_1 lab=out_cas_int_b22}
N 1123 26035 1103 26035 {lab=n_0737}
C {./lab_pin.sym} 1103 26035 0 0 {name=l1383_2 lab=n_0737}
N 1123 26055 1103 26055 {lab=n_0126}
C {./lab_pin.sym} 1103 26055 0 0 {name=l1383_3 lab=n_0126}
N 1307 25995 1327 25995 {lab=VDD}
C {./lab_pin.sym} 1327 25995 0 1 {name=l1383_4 lab=VDD}
N 1307 26015 1327 26015 {lab=VDD}
C {./lab_pin.sym} 1327 26015 0 1 {name=l1383_5 lab=VDD}
N 1307 26035 1327 26035 {lab=VSS}
C {./lab_pin.sym} 1327 26035 0 1 {name=l1383_6 lab=VSS}
N 1307 26055 1327 26055 {lab=VSS}
C {./lab_pin.sym} 1327 26055 0 1 {name=l1383_7 lab=VSS}
C {./nand2_1.sym} 1620 26025 0 0 {name=Xn_1325}
N 1528 25995 1508 25995 {lab=u_cas_int_out_int2_b23}
C {./lab_pin.sym} 1508 25995 0 0 {name=l1384_0 lab=u_cas_int_out_int2_b23}
N 1528 26015 1508 26015 {lab=out_cas_int_b23}
C {./lab_pin.sym} 1508 26015 0 0 {name=l1384_1 lab=out_cas_int_b23}
N 1528 26035 1508 26035 {lab=n_0741}
C {./lab_pin.sym} 1508 26035 0 0 {name=l1384_2 lab=n_0741}
N 1528 26055 1508 26055 {lab=VDD}
C {./lab_pin.sym} 1508 26055 0 0 {name=l1384_3 lab=VDD}
N 1712 26005 1732 26005 {lab=VDD}
C {./lab_pin.sym} 1732 26005 0 1 {name=l1384_4 lab=VDD}
N 1712 26025 1732 26025 {lab=VSS}
C {./lab_pin.sym} 1732 26025 0 1 {name=l1384_5 lab=VSS}
N 1712 26045 1732 26045 {lab=VSS}
C {./lab_pin.sym} 1732 26045 0 1 {name=l1384_6 lab=VSS}
C {./xor2_1.sym} 2025 26025 0 0 {name=Xn_1326}
N 1933 25995 1913 25995 {lab=u_cas_int_out_int2_b23}
C {./lab_pin.sym} 1913 25995 0 0 {name=l1385_0 lab=u_cas_int_out_int2_b23}
N 1933 26015 1913 26015 {lab=n_0496}
C {./lab_pin.sym} 1913 26015 0 0 {name=l1385_1 lab=n_0496}
N 1933 26035 1913 26035 {lab=n_0742}
C {./lab_pin.sym} 1913 26035 0 0 {name=l1385_2 lab=n_0742}
N 1933 26055 1913 26055 {lab=VDD}
C {./lab_pin.sym} 1913 26055 0 0 {name=l1385_3 lab=VDD}
N 2117 26005 2137 26005 {lab=VDD}
C {./lab_pin.sym} 2137 26005 0 1 {name=l1385_4 lab=VDD}
N 2117 26025 2137 26025 {lab=VSS}
C {./lab_pin.sym} 2137 26025 0 1 {name=l1385_5 lab=VSS}
N 2117 26045 2137 26045 {lab=VSS}
C {./lab_pin.sym} 2137 26045 0 1 {name=l1385_6 lab=VSS}
C {./oai21_1.sym} 2430 26025 0 0 {name=Xn_1327}
N 2338 25995 2318 25995 {lab=n_0736}
C {./lab_pin.sym} 2318 25995 0 0 {name=l1386_0 lab=n_0736}
N 2338 26015 2318 26015 {lab=n_0738}
C {./lab_pin.sym} 2318 26015 0 0 {name=l1386_1 lab=n_0738}
N 2338 26035 2318 26035 {lab=n_0740}
C {./lab_pin.sym} 2318 26035 0 0 {name=l1386_2 lab=n_0740}
N 2338 26055 2318 26055 {lab=n_0743}
C {./lab_pin.sym} 2318 26055 0 0 {name=l1386_3 lab=n_0743}
N 2522 25995 2542 25995 {lab=VDD}
C {./lab_pin.sym} 2542 25995 0 1 {name=l1386_4 lab=VDD}
N 2522 26015 2542 26015 {lab=VDD}
C {./lab_pin.sym} 2542 26015 0 1 {name=l1386_5 lab=VDD}
N 2522 26035 2542 26035 {lab=VSS}
C {./lab_pin.sym} 2542 26035 0 1 {name=l1386_6 lab=VSS}
N 2522 26055 2542 26055 {lab=VSS}
C {./lab_pin.sym} 2542 26055 0 1 {name=l1386_7 lab=VSS}
C {./nand2_1.sym} 2835 26025 0 0 {name=Xn_1328}
N 2743 25995 2723 25995 {lab=n_0742}
C {./lab_pin.sym} 2723 25995 0 0 {name=l1387_0 lab=n_0742}
N 2743 26015 2723 26015 {lab=n_0743}
C {./lab_pin.sym} 2723 26015 0 0 {name=l1387_1 lab=n_0743}
N 2743 26035 2723 26035 {lab=n_0744}
C {./lab_pin.sym} 2723 26035 0 0 {name=l1387_2 lab=n_0744}
N 2743 26055 2723 26055 {lab=VDD}
C {./lab_pin.sym} 2723 26055 0 0 {name=l1387_3 lab=VDD}
N 2927 26005 2947 26005 {lab=VDD}
C {./lab_pin.sym} 2947 26005 0 1 {name=l1387_4 lab=VDD}
N 2927 26025 2947 26025 {lab=VSS}
C {./lab_pin.sym} 2947 26025 0 1 {name=l1387_5 lab=VSS}
N 2927 26045 2947 26045 {lab=VSS}
C {./lab_pin.sym} 2947 26045 0 1 {name=l1387_6 lab=VSS}
C {./aoi21_1.sym} 3240 26025 0 0 {name=Xn_1329}
N 3148 25995 3128 25995 {lab=u_cas_int_out_int2_b22}
C {./lab_pin.sym} 3128 25995 0 0 {name=l1388_0 lab=u_cas_int_out_int2_b22}
N 3148 26015 3128 26015 {lab=out_cas_int_b22}
C {./lab_pin.sym} 3128 26015 0 0 {name=l1388_1 lab=out_cas_int_b22}
N 3148 26035 3128 26035 {lab=n_0742}
C {./lab_pin.sym} 3128 26035 0 0 {name=l1388_2 lab=n_0742}
N 3148 26055 3128 26055 {lab=n_0745}
C {./lab_pin.sym} 3128 26055 0 0 {name=l1388_3 lab=n_0745}
N 3332 25995 3352 25995 {lab=VDD}
C {./lab_pin.sym} 3352 25995 0 1 {name=l1388_4 lab=VDD}
N 3332 26015 3352 26015 {lab=VDD}
C {./lab_pin.sym} 3352 26015 0 1 {name=l1388_5 lab=VDD}
N 3332 26035 3352 26035 {lab=VSS}
C {./lab_pin.sym} 3352 26035 0 1 {name=l1388_6 lab=VSS}
N 3332 26055 3352 26055 {lab=VSS}
C {./lab_pin.sym} 3352 26055 0 1 {name=l1388_7 lab=VSS}
C {./oai31_1.sym} 3645 26025 0 0 {name=Xn_1330}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__oai31_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -60 72 -60 {}
L 4 72 -60 72 60 {}
L 4 72 60 -72 60 {}
L 4 -72 60 -72 -60 {}
T {@name} -72 -80 0 0 0.33 0.33 {}
T {oai31_1} -68 49 0 0 0.2 0.2 {}
L 4 -92 -40 -72 -40 {}
T {A1} -66 -45 0 0 0.16 0.16 {}
L 4 -92 -20 -72 -20 {}
T {A2} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {A3} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {B} -66 15 0 0 0.16 0.16 {}
L 4 -92 40 -72 40 {}
T {ZN} -66 35 0 0 0.16 0.16 {}
L 4 92 -30 72 -30 {}
T {VDD} 50.2 -35 0 0 0.16 0.16 {}
L 4 92 -10 72 -10 {}
T {VNW} 50.2 -15 0 0 0.16 0.16 {}
L 4 92 10 72 10 {}
T {VPW} 50.2 5 0 0 0.16 0.16 {}
L 4 92 30 72 30 {}
T {VSS} 50.2 25 0 0 0.16 0.16 {}
B 5 -94 -42 -90 -38 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -22 -90 -18 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 -2 -90 2 {name=A3 dir=inout sim_pinnumber=3}
B 5 -94 18 -90 22 {name=B dir=inout sim_pinnumber=4}
B 5 -94 38 -90 42 {name=ZN dir=inout sim_pinnumber=5}
B 5 90 -32 94 -28 {name=VDD dir=inout sim_pinnumber=6}
B 5 90 -12 94 -8 {name=VNW dir=inout sim_pinnumber=7}
B 5 90 8 94 12 {name=VPW dir=inout sim_pinnumber=8}
B 5 90 28 94 32 {name=VSS dir=inout sim_pinnumber=9}
]
N 3553 25985 3533 25985 {lab=n_0736}
C {./lab_pin.sym} 3533 25985 0 0 {name=l1389_0 lab=n_0736}
N 3553 26005 3533 26005 {lab=n_0738}
C {./lab_pin.sym} 3533 26005 0 0 {name=l1389_1 lab=n_0738}
N 3553 26025 3533 26025 {lab=n_0739}
C {./lab_pin.sym} 3533 26025 0 0 {name=l1389_2 lab=n_0739}
N 3553 26045 3533 26045 {lab=n_0745}
C {./lab_pin.sym} 3533 26045 0 0 {name=l1389_3 lab=n_0745}
N 3553 26065 3533 26065 {lab=n_0746}
C {./lab_pin.sym} 3533 26065 0 0 {name=l1389_4 lab=n_0746}
N 3737 25995 3757 25995 {lab=VDD}
C {./lab_pin.sym} 3757 25995 0 1 {name=l1389_5 lab=VDD}
N 3737 26015 3757 26015 {lab=VDD}
C {./lab_pin.sym} 3757 26015 0 1 {name=l1389_6 lab=VDD}
N 3737 26035 3757 26035 {lab=VSS}
C {./lab_pin.sym} 3757 26035 0 1 {name=l1389_7 lab=VSS}
N 3737 26055 3757 26055 {lab=VSS}
C {./lab_pin.sym} 3757 26055 0 1 {name=l1389_8 lab=VSS}
C {./nand2_1.sym} 4050 26025 0 0 {name=Xn_1331}
N 3958 25995 3938 25995 {lab=n_0744}
C {./lab_pin.sym} 3938 25995 0 0 {name=l1390_0 lab=n_0744}
N 3958 26015 3938 26015 {lab=n_0746}
C {./lab_pin.sym} 3938 26015 0 0 {name=l1390_1 lab=n_0746}
N 3958 26035 3938 26035 {lab=n_0127}
C {./lab_pin.sym} 3938 26035 0 0 {name=l1390_2 lab=n_0127}
N 3958 26055 3938 26055 {lab=VDD}
C {./lab_pin.sym} 3938 26055 0 0 {name=l1390_3 lab=VDD}
N 4142 26005 4162 26005 {lab=VDD}
C {./lab_pin.sym} 4162 26005 0 1 {name=l1390_4 lab=VDD}
N 4142 26025 4162 26025 {lab=VSS}
C {./lab_pin.sym} 4162 26025 0 1 {name=l1390_5 lab=VSS}
N 4142 26045 4162 26045 {lab=VSS}
C {./lab_pin.sym} 4162 26045 0 1 {name=l1390_6 lab=VSS}
C {./nor3_1.sym} 4455 26025 0 0 {name=Xn_1332}
N 4363 25995 4343 25995 {lab=n_0742}
C {./lab_pin.sym} 4343 25995 0 0 {name=l1391_0 lab=n_0742}
N 4363 26015 4343 26015 {lab=n_0739}
C {./lab_pin.sym} 4343 26015 0 0 {name=l1391_1 lab=n_0739}
N 4363 26035 4343 26035 {lab=n_0738}
C {./lab_pin.sym} 4343 26035 0 0 {name=l1391_2 lab=n_0738}
N 4363 26055 4343 26055 {lab=n_0747}
C {./lab_pin.sym} 4343 26055 0 0 {name=l1391_3 lab=n_0747}
N 4547 25995 4567 25995 {lab=VDD}
C {./lab_pin.sym} 4567 25995 0 1 {name=l1391_4 lab=VDD}
N 4547 26015 4567 26015 {lab=VDD}
C {./lab_pin.sym} 4567 26015 0 1 {name=l1391_5 lab=VDD}
N 4547 26035 4567 26035 {lab=VSS}
C {./lab_pin.sym} 4567 26035 0 1 {name=l1391_6 lab=VSS}
N 4547 26055 4567 26055 {lab=VSS}
C {./lab_pin.sym} 4567 26055 0 1 {name=l1391_7 lab=VSS}
C {./clkinv_1.sym} 0 26250 0 0 {name=Xn_1333}
N -92 26230 -112 26230 {lab=n_0747}
C {./lab_pin.sym} -112 26230 0 0 {name=l1392_0 lab=n_0747}
N -92 26250 -112 26250 {lab=n_0748}
C {./lab_pin.sym} -112 26250 0 0 {name=l1392_1 lab=n_0748}
N -92 26270 -112 26270 {lab=VDD}
C {./lab_pin.sym} -112 26270 0 0 {name=l1392_2 lab=VDD}
N 92 26230 112 26230 {lab=VDD}
C {./lab_pin.sym} 112 26230 0 1 {name=l1392_3 lab=VDD}
N 92 26250 112 26250 {lab=VSS}
C {./lab_pin.sym} 112 26250 0 1 {name=l1392_4 lab=VSS}
N 92 26270 112 26270 {lab=VSS}
C {./lab_pin.sym} 112 26270 0 1 {name=l1392_5 lab=VSS}
C {./nand2_1.sym} 405 26250 0 0 {name=Xn_1334}
N 313 26220 293 26220 {lab=n_0737}
C {./lab_pin.sym} 293 26220 0 0 {name=l1393_0 lab=n_0737}
N 313 26240 293 26240 {lab=n_0747}
C {./lab_pin.sym} 293 26240 0 0 {name=l1393_1 lab=n_0747}
N 313 26260 293 26260 {lab=n_0749}
C {./lab_pin.sym} 293 26260 0 0 {name=l1393_2 lab=n_0749}
N 313 26280 293 26280 {lab=VDD}
C {./lab_pin.sym} 293 26280 0 0 {name=l1393_3 lab=VDD}
N 497 26230 517 26230 {lab=VDD}
C {./lab_pin.sym} 517 26230 0 1 {name=l1393_4 lab=VDD}
N 497 26250 517 26250 {lab=VSS}
C {./lab_pin.sym} 517 26250 0 1 {name=l1393_5 lab=VSS}
N 497 26270 517 26270 {lab=VSS}
C {./lab_pin.sym} 517 26270 0 1 {name=l1393_6 lab=VSS}
C {./oai211_1.sym} 810 26250 0 0 {name=Xn_1335}
N 718 26210 698 26210 {lab=u_cas_int_out_int2_b23}
C {./lab_pin.sym} 698 26210 0 0 {name=l1394_0 lab=u_cas_int_out_int2_b23}
N 718 26230 698 26230 {lab=out_cas_int_b23}
C {./lab_pin.sym} 698 26230 0 0 {name=l1394_1 lab=out_cas_int_b23}
N 718 26250 698 26250 {lab=u_cas_int_out_int2_b22}
C {./lab_pin.sym} 698 26250 0 0 {name=l1394_2 lab=u_cas_int_out_int2_b22}
N 718 26270 698 26270 {lab=out_cas_int_b22}
C {./lab_pin.sym} 698 26270 0 0 {name=l1394_3 lab=out_cas_int_b22}
N 718 26290 698 26290 {lab=n_0750}
C {./lab_pin.sym} 698 26290 0 0 {name=l1394_4 lab=n_0750}
N 902 26220 922 26220 {lab=VDD}
C {./lab_pin.sym} 922 26220 0 1 {name=l1394_5 lab=VDD}
N 902 26240 922 26240 {lab=VDD}
C {./lab_pin.sym} 922 26240 0 1 {name=l1394_6 lab=VDD}
N 902 26260 922 26260 {lab=VSS}
C {./lab_pin.sym} 922 26260 0 1 {name=l1394_7 lab=VSS}
N 902 26280 922 26280 {lab=VSS}
C {./lab_pin.sym} 922 26280 0 1 {name=l1394_8 lab=VSS}
C {./and2_1.sym} 1215 26250 0 0 {name=Xn_1336}
N 1123 26220 1103 26220 {lab=n_0741}
C {./lab_pin.sym} 1103 26220 0 0 {name=l1395_0 lab=n_0741}
N 1123 26240 1103 26240 {lab=n_0750}
C {./lab_pin.sym} 1103 26240 0 0 {name=l1395_1 lab=n_0750}
N 1123 26260 1103 26260 {lab=n_0751}
C {./lab_pin.sym} 1103 26260 0 0 {name=l1395_2 lab=n_0751}
N 1123 26280 1103 26280 {lab=VDD}
C {./lab_pin.sym} 1103 26280 0 0 {name=l1395_3 lab=VDD}
N 1307 26230 1327 26230 {lab=VDD}
C {./lab_pin.sym} 1327 26230 0 1 {name=l1395_4 lab=VDD}
N 1307 26250 1327 26250 {lab=VSS}
C {./lab_pin.sym} 1327 26250 0 1 {name=l1395_5 lab=VSS}
N 1307 26270 1327 26270 {lab=VSS}
C {./lab_pin.sym} 1327 26270 0 1 {name=l1395_6 lab=VSS}
C {./xnor2_1.sym} 1620 26250 0 0 {name=Xn_1337}
N 1528 26220 1508 26220 {lab=u_cas_int_out_int2_b24}
C {./lab_pin.sym} 1508 26220 0 0 {name=l1396_0 lab=u_cas_int_out_int2_b24}
N 1528 26240 1508 26240 {lab=out_cas_int_b24}
C {./lab_pin.sym} 1508 26240 0 0 {name=l1396_1 lab=out_cas_int_b24}
N 1528 26260 1508 26260 {lab=n_0752}
C {./lab_pin.sym} 1508 26260 0 0 {name=l1396_2 lab=n_0752}
N 1528 26280 1508 26280 {lab=VDD}
C {./lab_pin.sym} 1508 26280 0 0 {name=l1396_3 lab=VDD}
N 1712 26230 1732 26230 {lab=VDD}
C {./lab_pin.sym} 1732 26230 0 1 {name=l1396_4 lab=VDD}
N 1712 26250 1732 26250 {lab=VSS}
C {./lab_pin.sym} 1732 26250 0 1 {name=l1396_5 lab=VSS}
N 1712 26270 1732 26270 {lab=VSS}
C {./lab_pin.sym} 1732 26270 0 1 {name=l1396_6 lab=VSS}
C {./aoi21_1.sym} 2025 26250 0 0 {name=Xn_1338}
N 1933 26220 1913 26220 {lab=n_0749}
C {./lab_pin.sym} 1913 26220 0 0 {name=l1397_0 lab=n_0749}
N 1933 26240 1913 26240 {lab=n_0751}
C {./lab_pin.sym} 1913 26240 0 0 {name=l1397_1 lab=n_0751}
N 1933 26260 1913 26260 {lab=n_0752}
C {./lab_pin.sym} 1913 26260 0 0 {name=l1397_2 lab=n_0752}
N 1933 26280 1913 26280 {lab=n_0753}
C {./lab_pin.sym} 1913 26280 0 0 {name=l1397_3 lab=n_0753}
N 2117 26220 2137 26220 {lab=VDD}
C {./lab_pin.sym} 2137 26220 0 1 {name=l1397_4 lab=VDD}
N 2117 26240 2137 26240 {lab=VDD}
C {./lab_pin.sym} 2137 26240 0 1 {name=l1397_5 lab=VDD}
N 2117 26260 2137 26260 {lab=VSS}
C {./lab_pin.sym} 2137 26260 0 1 {name=l1397_6 lab=VSS}
N 2117 26280 2137 26280 {lab=VSS}
C {./lab_pin.sym} 2137 26280 0 1 {name=l1397_7 lab=VSS}
C {./and3_1.sym} 2430 26250 0 0 {name=Xn_1339}
N 2338 26220 2318 26220 {lab=n_0741}
C {./lab_pin.sym} 2318 26220 0 0 {name=l1398_0 lab=n_0741}
N 2338 26240 2318 26240 {lab=n_0750}
C {./lab_pin.sym} 2318 26240 0 0 {name=l1398_1 lab=n_0750}
N 2338 26260 2318 26260 {lab=n_0752}
C {./lab_pin.sym} 2318 26260 0 0 {name=l1398_2 lab=n_0752}
N 2338 26280 2318 26280 {lab=n_0754}
C {./lab_pin.sym} 2318 26280 0 0 {name=l1398_3 lab=n_0754}
N 2522 26220 2542 26220 {lab=VDD}
C {./lab_pin.sym} 2542 26220 0 1 {name=l1398_4 lab=VDD}
N 2522 26240 2542 26240 {lab=VDD}
C {./lab_pin.sym} 2542 26240 0 1 {name=l1398_5 lab=VDD}
N 2522 26260 2542 26260 {lab=VSS}
C {./lab_pin.sym} 2542 26260 0 1 {name=l1398_6 lab=VSS}
N 2522 26280 2542 26280 {lab=VSS}
C {./lab_pin.sym} 2542 26280 0 1 {name=l1398_7 lab=VSS}
C {./oai21_1.sym} 2835 26250 0 0 {name=Xn_1340}
N 2743 26220 2723 26220 {lab=n_0736}
C {./lab_pin.sym} 2723 26220 0 0 {name=l1399_0 lab=n_0736}
N 2743 26240 2723 26240 {lab=n_0748}
C {./lab_pin.sym} 2723 26240 0 0 {name=l1399_1 lab=n_0748}
N 2743 26260 2723 26260 {lab=n_0754}
C {./lab_pin.sym} 2723 26260 0 0 {name=l1399_2 lab=n_0754}
N 2743 26280 2723 26280 {lab=n_0755}
C {./lab_pin.sym} 2723 26280 0 0 {name=l1399_3 lab=n_0755}
N 2927 26220 2947 26220 {lab=VDD}
C {./lab_pin.sym} 2947 26220 0 1 {name=l1399_4 lab=VDD}
N 2927 26240 2947 26240 {lab=VDD}
C {./lab_pin.sym} 2947 26240 0 1 {name=l1399_5 lab=VDD}
N 2927 26260 2947 26260 {lab=VSS}
C {./lab_pin.sym} 2947 26260 0 1 {name=l1399_6 lab=VSS}
N 2927 26280 2947 26280 {lab=VSS}
C {./lab_pin.sym} 2947 26280 0 1 {name=l1399_7 lab=VSS}
C {./clkinv_1.sym} 3240 26250 0 0 {name=Xn_1341}
N 3148 26230 3128 26230 {lab=n_0755}
C {./lab_pin.sym} 3128 26230 0 0 {name=l1400_0 lab=n_0755}
N 3148 26250 3128 26250 {lab=n_0756}
C {./lab_pin.sym} 3128 26250 0 0 {name=l1400_1 lab=n_0756}
N 3148 26270 3128 26270 {lab=VDD}
C {./lab_pin.sym} 3128 26270 0 0 {name=l1400_2 lab=VDD}
N 3332 26230 3352 26230 {lab=VDD}
C {./lab_pin.sym} 3352 26230 0 1 {name=l1400_3 lab=VDD}
N 3332 26250 3352 26250 {lab=VSS}
C {./lab_pin.sym} 3352 26250 0 1 {name=l1400_4 lab=VSS}
N 3332 26270 3352 26270 {lab=VSS}
C {./lab_pin.sym} 3352 26270 0 1 {name=l1400_5 lab=VSS}
C {./nor2_1.sym} 3645 26250 0 0 {name=Xn_1342}
N 3553 26220 3533 26220 {lab=n_0753}
C {./lab_pin.sym} 3533 26220 0 0 {name=l1401_0 lab=n_0753}
N 3553 26240 3533 26240 {lab=n_0756}
C {./lab_pin.sym} 3533 26240 0 0 {name=l1401_1 lab=n_0756}
N 3553 26260 3533 26260 {lab=n_0128}
C {./lab_pin.sym} 3533 26260 0 0 {name=l1401_2 lab=n_0128}
N 3553 26280 3533 26280 {lab=VDD}
C {./lab_pin.sym} 3533 26280 0 0 {name=l1401_3 lab=VDD}
N 3737 26230 3757 26230 {lab=VDD}
C {./lab_pin.sym} 3757 26230 0 1 {name=l1401_4 lab=VDD}
N 3737 26250 3757 26250 {lab=VSS}
C {./lab_pin.sym} 3757 26250 0 1 {name=l1401_5 lab=VSS}
N 3737 26270 3757 26270 {lab=VSS}
C {./lab_pin.sym} 3757 26270 0 1 {name=l1401_6 lab=VSS}
C {./nand2_1.sym} 4050 26250 0 0 {name=Xn_1343}
N 3958 26220 3938 26220 {lab=u_cas_int_out_int2_b1}
C {./lab_pin.sym} 3938 26220 0 0 {name=l1402_0 lab=u_cas_int_out_int2_b1}
N 3958 26240 3938 26240 {lab=u_cas_int_out_int1_b1}
C {./lab_pin.sym} 3938 26240 0 0 {name=l1402_1 lab=u_cas_int_out_int1_b1}
N 3958 26260 3938 26260 {lab=n_0757}
C {./lab_pin.sym} 3938 26260 0 0 {name=l1402_2 lab=n_0757}
N 3958 26280 3938 26280 {lab=VDD}
C {./lab_pin.sym} 3938 26280 0 0 {name=l1402_3 lab=VDD}
N 4142 26230 4162 26230 {lab=VDD}
C {./lab_pin.sym} 4162 26230 0 1 {name=l1402_4 lab=VDD}
N 4142 26250 4162 26250 {lab=VSS}
C {./lab_pin.sym} 4162 26250 0 1 {name=l1402_5 lab=VSS}
N 4142 26270 4162 26270 {lab=VSS}
C {./lab_pin.sym} 4162 26270 0 1 {name=l1402_6 lab=VSS}
C {./nand2_1.sym} 4455 26250 0 0 {name=Xn_1344}
N 4363 26220 4343 26220 {lab=u_cas_int_out_int2_b0}
C {./lab_pin.sym} 4343 26220 0 0 {name=l1403_0 lab=u_cas_int_out_int2_b0}
N 4363 26240 4343 26240 {lab=u_cas_int_out_int1_b0}
C {./lab_pin.sym} 4343 26240 0 0 {name=l1403_1 lab=u_cas_int_out_int1_b0}
N 4363 26260 4343 26260 {lab=n_0758}
C {./lab_pin.sym} 4343 26260 0 0 {name=l1403_2 lab=n_0758}
N 4363 26280 4343 26280 {lab=VDD}
C {./lab_pin.sym} 4343 26280 0 0 {name=l1403_3 lab=VDD}
N 4547 26230 4567 26230 {lab=VDD}
C {./lab_pin.sym} 4567 26230 0 1 {name=l1403_4 lab=VDD}
N 4547 26250 4567 26250 {lab=VSS}
C {./lab_pin.sym} 4567 26250 0 1 {name=l1403_5 lab=VSS}
N 4547 26270 4567 26270 {lab=VSS}
C {./lab_pin.sym} 4567 26270 0 1 {name=l1403_6 lab=VSS}
C {./xnor3_1.sym} 0 26475 0 0 {name=Xn_1345}
N -92 26445 -112 26445 {lab=u_cas_int_out_int2_b1}
C {./lab_pin.sym} -112 26445 0 0 {name=l1404_0 lab=u_cas_int_out_int2_b1}
N -92 26465 -112 26465 {lab=u_cas_int_out_int1_b1}
C {./lab_pin.sym} -112 26465 0 0 {name=l1404_1 lab=u_cas_int_out_int1_b1}
N -92 26485 -112 26485 {lab=n_0758}
C {./lab_pin.sym} -112 26485 0 0 {name=l1404_2 lab=n_0758}
N -92 26505 -112 26505 {lab=n_0098}
C {./lab_pin.sym} -112 26505 0 0 {name=l1404_3 lab=n_0098}
N 92 26445 112 26445 {lab=VDD}
C {./lab_pin.sym} 112 26445 0 1 {name=l1404_4 lab=VDD}
N 92 26465 112 26465 {lab=VDD}
C {./lab_pin.sym} 112 26465 0 1 {name=l1404_5 lab=VDD}
N 92 26485 112 26485 {lab=VSS}
C {./lab_pin.sym} 112 26485 0 1 {name=l1404_6 lab=VSS}
N 92 26505 112 26505 {lab=VSS}
C {./lab_pin.sym} 112 26505 0 1 {name=l1404_7 lab=VSS}
C {./and2_1.sym} 405 26475 0 0 {name=Xn_1346}
N 313 26445 293 26445 {lab=u_cas_int_out_int2_b2}
C {./lab_pin.sym} 293 26445 0 0 {name=l1405_0 lab=u_cas_int_out_int2_b2}
N 313 26465 293 26465 {lab=u_cas_int_out_int1_b2}
C {./lab_pin.sym} 293 26465 0 0 {name=l1405_1 lab=u_cas_int_out_int1_b2}
N 313 26485 293 26485 {lab=n_0759}
C {./lab_pin.sym} 293 26485 0 0 {name=l1405_2 lab=n_0759}
N 313 26505 293 26505 {lab=VDD}
C {./lab_pin.sym} 293 26505 0 0 {name=l1405_3 lab=VDD}
N 497 26455 517 26455 {lab=VDD}
C {./lab_pin.sym} 517 26455 0 1 {name=l1405_4 lab=VDD}
N 497 26475 517 26475 {lab=VSS}
C {./lab_pin.sym} 517 26475 0 1 {name=l1405_5 lab=VSS}
N 497 26495 517 26495 {lab=VSS}
C {./lab_pin.sym} 517 26495 0 1 {name=l1405_6 lab=VSS}
C {./nor2_1.sym} 810 26475 0 0 {name=Xn_1347}
N 718 26445 698 26445 {lab=u_cas_int_out_int2_b2}
C {./lab_pin.sym} 698 26445 0 0 {name=l1406_0 lab=u_cas_int_out_int2_b2}
N 718 26465 698 26465 {lab=u_cas_int_out_int1_b2}
C {./lab_pin.sym} 698 26465 0 0 {name=l1406_1 lab=u_cas_int_out_int1_b2}
N 718 26485 698 26485 {lab=n_0760}
C {./lab_pin.sym} 698 26485 0 0 {name=l1406_2 lab=n_0760}
N 718 26505 698 26505 {lab=VDD}
C {./lab_pin.sym} 698 26505 0 0 {name=l1406_3 lab=VDD}
N 902 26455 922 26455 {lab=VDD}
C {./lab_pin.sym} 922 26455 0 1 {name=l1406_4 lab=VDD}
N 902 26475 922 26475 {lab=VSS}
C {./lab_pin.sym} 922 26475 0 1 {name=l1406_5 lab=VSS}
N 902 26495 922 26495 {lab=VSS}
C {./lab_pin.sym} 922 26495 0 1 {name=l1406_6 lab=VSS}
C {./oai211_1.sym} 1215 26475 0 0 {name=Xn_1348}
N 1123 26435 1103 26435 {lab=u_cas_int_out_int2_b1}
C {./lab_pin.sym} 1103 26435 0 0 {name=l1407_0 lab=u_cas_int_out_int2_b1}
N 1123 26455 1103 26455 {lab=u_cas_int_out_int1_b1}
C {./lab_pin.sym} 1103 26455 0 0 {name=l1407_1 lab=u_cas_int_out_int1_b1}
N 1123 26475 1103 26475 {lab=u_cas_int_out_int1_b0}
C {./lab_pin.sym} 1103 26475 0 0 {name=l1407_2 lab=u_cas_int_out_int1_b0}
N 1123 26495 1103 26495 {lab=u_cas_int_out_int2_b0}
C {./lab_pin.sym} 1103 26495 0 0 {name=l1407_3 lab=u_cas_int_out_int2_b0}
N 1123 26515 1103 26515 {lab=n_0761}
C {./lab_pin.sym} 1103 26515 0 0 {name=l1407_4 lab=n_0761}
N 1307 26445 1327 26445 {lab=VDD}
C {./lab_pin.sym} 1327 26445 0 1 {name=l1407_5 lab=VDD}
N 1307 26465 1327 26465 {lab=VDD}
C {./lab_pin.sym} 1327 26465 0 1 {name=l1407_6 lab=VDD}
N 1307 26485 1327 26485 {lab=VSS}
C {./lab_pin.sym} 1327 26485 0 1 {name=l1407_7 lab=VSS}
N 1307 26505 1327 26505 {lab=VSS}
C {./lab_pin.sym} 1327 26505 0 1 {name=l1407_8 lab=VSS}
C {./nand2_1.sym} 1620 26475 0 0 {name=Xn_1349}
N 1528 26445 1508 26445 {lab=n_0757}
C {./lab_pin.sym} 1508 26445 0 0 {name=l1408_0 lab=n_0757}
N 1528 26465 1508 26465 {lab=n_0761}
C {./lab_pin.sym} 1508 26465 0 0 {name=l1408_1 lab=n_0761}
N 1528 26485 1508 26485 {lab=n_0762}
C {./lab_pin.sym} 1508 26485 0 0 {name=l1408_2 lab=n_0762}
N 1528 26505 1508 26505 {lab=VDD}
C {./lab_pin.sym} 1508 26505 0 0 {name=l1408_3 lab=VDD}
N 1712 26455 1732 26455 {lab=VDD}
C {./lab_pin.sym} 1732 26455 0 1 {name=l1408_4 lab=VDD}
N 1712 26475 1732 26475 {lab=VSS}
C {./lab_pin.sym} 1732 26475 0 1 {name=l1408_5 lab=VSS}
N 1712 26495 1732 26495 {lab=VSS}
C {./lab_pin.sym} 1732 26495 0 1 {name=l1408_6 lab=VSS}
C {./aoi211_1.sym} 2025 26475 0 0 {name=Xn_1350}
N 1933 26435 1913 26435 {lab=n_0757}
C {./lab_pin.sym} 1913 26435 0 0 {name=l1409_0 lab=n_0757}
N 1933 26455 1913 26455 {lab=n_0761}
C {./lab_pin.sym} 1913 26455 0 0 {name=l1409_1 lab=n_0761}
N 1933 26475 1913 26475 {lab=n_0760}
C {./lab_pin.sym} 1913 26475 0 0 {name=l1409_2 lab=n_0760}
N 1933 26495 1913 26495 {lab=n_0759}
C {./lab_pin.sym} 1913 26495 0 0 {name=l1409_3 lab=n_0759}
N 1933 26515 1913 26515 {lab=n_0763}
C {./lab_pin.sym} 1913 26515 0 0 {name=l1409_4 lab=n_0763}
N 2117 26445 2137 26445 {lab=VDD}
C {./lab_pin.sym} 2137 26445 0 1 {name=l1409_5 lab=VDD}
N 2117 26465 2137 26465 {lab=VDD}
C {./lab_pin.sym} 2137 26465 0 1 {name=l1409_6 lab=VDD}
N 2117 26485 2137 26485 {lab=VSS}
C {./lab_pin.sym} 2137 26485 0 1 {name=l1409_7 lab=VSS}
N 2117 26505 2137 26505 {lab=VSS}
C {./lab_pin.sym} 2137 26505 0 1 {name=l1409_8 lab=VSS}
C {./xor3_1.sym} 2430 26475 0 0 {name=Xn_1351}
N 2338 26445 2318 26445 {lab=u_cas_int_out_int2_b2}
C {./lab_pin.sym} 2318 26445 0 0 {name=l1410_0 lab=u_cas_int_out_int2_b2}
N 2338 26465 2318 26465 {lab=u_cas_int_out_int1_b2}
C {./lab_pin.sym} 2318 26465 0 0 {name=l1410_1 lab=u_cas_int_out_int1_b2}
N 2338 26485 2318 26485 {lab=n_0762}
C {./lab_pin.sym} 2318 26485 0 0 {name=l1410_2 lab=n_0762}
N 2338 26505 2318 26505 {lab=n_0104}
C {./lab_pin.sym} 2318 26505 0 0 {name=l1410_3 lab=n_0104}
N 2522 26445 2542 26445 {lab=VDD}
C {./lab_pin.sym} 2542 26445 0 1 {name=l1410_4 lab=VDD}
N 2522 26465 2542 26465 {lab=VDD}
C {./lab_pin.sym} 2542 26465 0 1 {name=l1410_5 lab=VDD}
N 2522 26485 2542 26485 {lab=VSS}
C {./lab_pin.sym} 2542 26485 0 1 {name=l1410_6 lab=VSS}
N 2522 26505 2542 26505 {lab=VSS}
C {./lab_pin.sym} 2542 26505 0 1 {name=l1410_7 lab=VSS}
C {./aoi21_1.sym} 2835 26475 0 0 {name=Xn_1352}
N 2743 26445 2723 26445 {lab=u_cas_int_out_int2_b2}
C {./lab_pin.sym} 2723 26445 0 0 {name=l1411_0 lab=u_cas_int_out_int2_b2}
N 2743 26465 2723 26465 {lab=u_cas_int_out_int1_b2}
C {./lab_pin.sym} 2723 26465 0 0 {name=l1411_1 lab=u_cas_int_out_int1_b2}
N 2743 26485 2723 26485 {lab=n_0763}
C {./lab_pin.sym} 2723 26485 0 0 {name=l1411_2 lab=n_0763}
N 2743 26505 2723 26505 {lab=n_0764}
C {./lab_pin.sym} 2723 26505 0 0 {name=l1411_3 lab=n_0764}
N 2927 26445 2947 26445 {lab=VDD}
C {./lab_pin.sym} 2947 26445 0 1 {name=l1411_4 lab=VDD}
N 2927 26465 2947 26465 {lab=VDD}
C {./lab_pin.sym} 2947 26465 0 1 {name=l1411_5 lab=VDD}
N 2927 26485 2947 26485 {lab=VSS}
C {./lab_pin.sym} 2947 26485 0 1 {name=l1411_6 lab=VSS}
N 2927 26505 2947 26505 {lab=VSS}
C {./lab_pin.sym} 2947 26505 0 1 {name=l1411_7 lab=VSS}
C {./nand2_1.sym} 3240 26475 0 0 {name=Xn_1353}
N 3148 26445 3128 26445 {lab=u_cas_int_out_int2_b3}
C {./lab_pin.sym} 3128 26445 0 0 {name=l1412_0 lab=u_cas_int_out_int2_b3}
N 3148 26465 3128 26465 {lab=u_cas_int_out_int1_b3}
C {./lab_pin.sym} 3128 26465 0 0 {name=l1412_1 lab=u_cas_int_out_int1_b3}
N 3148 26485 3128 26485 {lab=n_0765}
C {./lab_pin.sym} 3128 26485 0 0 {name=l1412_2 lab=n_0765}
N 3148 26505 3128 26505 {lab=VDD}
C {./lab_pin.sym} 3128 26505 0 0 {name=l1412_3 lab=VDD}
N 3332 26455 3352 26455 {lab=VDD}
C {./lab_pin.sym} 3352 26455 0 1 {name=l1412_4 lab=VDD}
N 3332 26475 3352 26475 {lab=VSS}
C {./lab_pin.sym} 3352 26475 0 1 {name=l1412_5 lab=VSS}
N 3332 26495 3352 26495 {lab=VSS}
C {./lab_pin.sym} 3352 26495 0 1 {name=l1412_6 lab=VSS}
C {./nor2_1.sym} 3645 26475 0 0 {name=Xn_1354}
N 3553 26445 3533 26445 {lab=u_cas_int_out_int2_b3}
C {./lab_pin.sym} 3533 26445 0 0 {name=l1413_0 lab=u_cas_int_out_int2_b3}
N 3553 26465 3533 26465 {lab=u_cas_int_out_int1_b3}
C {./lab_pin.sym} 3533 26465 0 0 {name=l1413_1 lab=u_cas_int_out_int1_b3}
N 3553 26485 3533 26485 {lab=n_0766}
C {./lab_pin.sym} 3533 26485 0 0 {name=l1413_2 lab=n_0766}
N 3553 26505 3533 26505 {lab=VDD}
C {./lab_pin.sym} 3533 26505 0 0 {name=l1413_3 lab=VDD}
N 3737 26455 3757 26455 {lab=VDD}
C {./lab_pin.sym} 3757 26455 0 1 {name=l1413_4 lab=VDD}
N 3737 26475 3757 26475 {lab=VSS}
C {./lab_pin.sym} 3757 26475 0 1 {name=l1413_5 lab=VSS}
N 3737 26495 3757 26495 {lab=VSS}
C {./lab_pin.sym} 3757 26495 0 1 {name=l1413_6 lab=VSS}
C {./xor2_1.sym} 4050 26475 0 0 {name=Xn_1355}
N 3958 26445 3938 26445 {lab=u_cas_int_out_int2_b3}
C {./lab_pin.sym} 3938 26445 0 0 {name=l1414_0 lab=u_cas_int_out_int2_b3}
N 3958 26465 3938 26465 {lab=u_cas_int_out_int1_b3}
C {./lab_pin.sym} 3938 26465 0 0 {name=l1414_1 lab=u_cas_int_out_int1_b3}
N 3958 26485 3938 26485 {lab=n_0767}
C {./lab_pin.sym} 3938 26485 0 0 {name=l1414_2 lab=n_0767}
N 3958 26505 3938 26505 {lab=VDD}
C {./lab_pin.sym} 3938 26505 0 0 {name=l1414_3 lab=VDD}
N 4142 26455 4162 26455 {lab=VDD}
C {./lab_pin.sym} 4162 26455 0 1 {name=l1414_4 lab=VDD}
N 4142 26475 4162 26475 {lab=VSS}
C {./lab_pin.sym} 4162 26475 0 1 {name=l1414_5 lab=VSS}
N 4142 26495 4162 26495 {lab=VSS}
C {./lab_pin.sym} 4162 26495 0 1 {name=l1414_6 lab=VSS}
C {./xnor2_1.sym} 4455 26475 0 0 {name=Xn_1356}
N 4363 26445 4343 26445 {lab=n_0764}
C {./lab_pin.sym} 4343 26445 0 0 {name=l1415_0 lab=n_0764}
N 4363 26465 4343 26465 {lab=n_0767}
C {./lab_pin.sym} 4343 26465 0 0 {name=l1415_1 lab=n_0767}
N 4363 26485 4343 26485 {lab=n_0105}
C {./lab_pin.sym} 4343 26485 0 0 {name=l1415_2 lab=n_0105}
N 4363 26505 4343 26505 {lab=VDD}
C {./lab_pin.sym} 4343 26505 0 0 {name=l1415_3 lab=VDD}
N 4547 26455 4567 26455 {lab=VDD}
C {./lab_pin.sym} 4567 26455 0 1 {name=l1415_4 lab=VDD}
N 4547 26475 4567 26475 {lab=VSS}
C {./lab_pin.sym} 4567 26475 0 1 {name=l1415_5 lab=VSS}
N 4547 26495 4567 26495 {lab=VSS}
C {./lab_pin.sym} 4567 26495 0 1 {name=l1415_6 lab=VSS}
C {./oai211_1.sym} 0 26700 0 0 {name=Xn_1357}
N -92 26660 -112 26660 {lab=u_cas_int_out_int2_b3}
C {./lab_pin.sym} -112 26660 0 0 {name=l1416_0 lab=u_cas_int_out_int2_b3}
N -92 26680 -112 26680 {lab=u_cas_int_out_int1_b3}
C {./lab_pin.sym} -112 26680 0 0 {name=l1416_1 lab=u_cas_int_out_int1_b3}
N -92 26700 -112 26700 {lab=u_cas_int_out_int1_b2}
C {./lab_pin.sym} -112 26700 0 0 {name=l1416_2 lab=u_cas_int_out_int1_b2}
N -92 26720 -112 26720 {lab=u_cas_int_out_int2_b2}
C {./lab_pin.sym} -112 26720 0 0 {name=l1416_3 lab=u_cas_int_out_int2_b2}
N -92 26740 -112 26740 {lab=n_0768}
C {./lab_pin.sym} -112 26740 0 0 {name=l1416_4 lab=n_0768}
N 92 26670 112 26670 {lab=VDD}
C {./lab_pin.sym} 112 26670 0 1 {name=l1416_5 lab=VDD}
N 92 26690 112 26690 {lab=VDD}
C {./lab_pin.sym} 112 26690 0 1 {name=l1416_6 lab=VDD}
N 92 26710 112 26710 {lab=VSS}
C {./lab_pin.sym} 112 26710 0 1 {name=l1416_7 lab=VSS}
N 92 26730 112 26730 {lab=VSS}
C {./lab_pin.sym} 112 26730 0 1 {name=l1416_8 lab=VSS}
C {./nand2_1.sym} 405 26700 0 0 {name=Xn_1358}
N 313 26670 293 26670 {lab=n_0765}
C {./lab_pin.sym} 293 26670 0 0 {name=l1417_0 lab=n_0765}
N 313 26690 293 26690 {lab=n_0768}
C {./lab_pin.sym} 293 26690 0 0 {name=l1417_1 lab=n_0768}
N 313 26710 293 26710 {lab=n_0769}
C {./lab_pin.sym} 293 26710 0 0 {name=l1417_2 lab=n_0769}
N 313 26730 293 26730 {lab=VDD}
C {./lab_pin.sym} 293 26730 0 0 {name=l1417_3 lab=VDD}
N 497 26680 517 26680 {lab=VDD}
C {./lab_pin.sym} 517 26680 0 1 {name=l1417_4 lab=VDD}
N 497 26700 517 26700 {lab=VSS}
C {./lab_pin.sym} 517 26700 0 1 {name=l1417_5 lab=VSS}
N 497 26720 517 26720 {lab=VSS}
C {./lab_pin.sym} 517 26720 0 1 {name=l1417_6 lab=VSS}
C {./aoi21_1.sym} 810 26700 0 0 {name=Xn_1359}
N 718 26670 698 26670 {lab=n_0764}
C {./lab_pin.sym} 698 26670 0 0 {name=l1418_0 lab=n_0764}
N 718 26690 698 26690 {lab=n_0765}
C {./lab_pin.sym} 698 26690 0 0 {name=l1418_1 lab=n_0765}
N 718 26710 698 26710 {lab=n_0766}
C {./lab_pin.sym} 698 26710 0 0 {name=l1418_2 lab=n_0766}
N 718 26730 698 26730 {lab=n_0770}
C {./lab_pin.sym} 698 26730 0 0 {name=l1418_3 lab=n_0770}
N 902 26670 922 26670 {lab=VDD}
C {./lab_pin.sym} 922 26670 0 1 {name=l1418_4 lab=VDD}
N 902 26690 922 26690 {lab=VDD}
C {./lab_pin.sym} 922 26690 0 1 {name=l1418_5 lab=VDD}
N 902 26710 922 26710 {lab=VSS}
C {./lab_pin.sym} 922 26710 0 1 {name=l1418_6 lab=VSS}
N 902 26730 922 26730 {lab=VSS}
C {./lab_pin.sym} 922 26730 0 1 {name=l1418_7 lab=VSS}
C {./aoi21_1.sym} 1215 26700 0 0 {name=Xn_1360}
N 1123 26670 1103 26670 {lab=n_0763}
C {./lab_pin.sym} 1103 26670 0 0 {name=l1419_0 lab=n_0763}
N 1123 26690 1103 26690 {lab=n_0767}
C {./lab_pin.sym} 1103 26690 0 0 {name=l1419_1 lab=n_0767}
N 1123 26710 1103 26710 {lab=n_0769}
C {./lab_pin.sym} 1103 26710 0 0 {name=l1419_2 lab=n_0769}
N 1123 26730 1103 26730 {lab=n_0771}
C {./lab_pin.sym} 1103 26730 0 0 {name=l1419_3 lab=n_0771}
N 1307 26670 1327 26670 {lab=VDD}
C {./lab_pin.sym} 1327 26670 0 1 {name=l1419_4 lab=VDD}
N 1307 26690 1327 26690 {lab=VDD}
C {./lab_pin.sym} 1327 26690 0 1 {name=l1419_5 lab=VDD}
N 1307 26710 1327 26710 {lab=VSS}
C {./lab_pin.sym} 1327 26710 0 1 {name=l1419_6 lab=VSS}
N 1307 26730 1327 26730 {lab=VSS}
C {./lab_pin.sym} 1327 26730 0 1 {name=l1419_7 lab=VSS}
C {./nand2_1.sym} 1620 26700 0 0 {name=Xn_1361}
N 1528 26670 1508 26670 {lab=u_cas_int_out_int2_b4}
C {./lab_pin.sym} 1508 26670 0 0 {name=l1420_0 lab=u_cas_int_out_int2_b4}
N 1528 26690 1508 26690 {lab=u_cas_int_out_int1_b4}
C {./lab_pin.sym} 1508 26690 0 0 {name=l1420_1 lab=u_cas_int_out_int1_b4}
N 1528 26710 1508 26710 {lab=n_0772}
C {./lab_pin.sym} 1508 26710 0 0 {name=l1420_2 lab=n_0772}
N 1528 26730 1508 26730 {lab=VDD}
C {./lab_pin.sym} 1508 26730 0 0 {name=l1420_3 lab=VDD}
N 1712 26680 1732 26680 {lab=VDD}
C {./lab_pin.sym} 1732 26680 0 1 {name=l1420_4 lab=VDD}
N 1712 26700 1732 26700 {lab=VSS}
C {./lab_pin.sym} 1732 26700 0 1 {name=l1420_5 lab=VSS}
N 1712 26720 1732 26720 {lab=VSS}
C {./lab_pin.sym} 1732 26720 0 1 {name=l1420_6 lab=VSS}
C {./or2_1.sym} 2025 26700 0 0 {name=Xn_1362}
N 1933 26670 1913 26670 {lab=u_cas_int_out_int2_b4}
C {./lab_pin.sym} 1913 26670 0 0 {name=l1421_0 lab=u_cas_int_out_int2_b4}
N 1933 26690 1913 26690 {lab=u_cas_int_out_int1_b4}
C {./lab_pin.sym} 1913 26690 0 0 {name=l1421_1 lab=u_cas_int_out_int1_b4}
N 1933 26710 1913 26710 {lab=n_0773}
C {./lab_pin.sym} 1913 26710 0 0 {name=l1421_2 lab=n_0773}
N 1933 26730 1913 26730 {lab=VDD}
C {./lab_pin.sym} 1913 26730 0 0 {name=l1421_3 lab=VDD}
N 2117 26680 2137 26680 {lab=VDD}
C {./lab_pin.sym} 2137 26680 0 1 {name=l1421_4 lab=VDD}
N 2117 26700 2137 26700 {lab=VSS}
C {./lab_pin.sym} 2137 26700 0 1 {name=l1421_5 lab=VSS}
N 2117 26720 2137 26720 {lab=VSS}
C {./lab_pin.sym} 2137 26720 0 1 {name=l1421_6 lab=VSS}
C {./nand3_1.sym} 2430 26700 0 0 {name=Xn_1363}
N 2338 26670 2318 26670 {lab=n_0770}
C {./lab_pin.sym} 2318 26670 0 0 {name=l1422_0 lab=n_0770}
N 2338 26690 2318 26690 {lab=n_0772}
C {./lab_pin.sym} 2318 26690 0 0 {name=l1422_1 lab=n_0772}
N 2338 26710 2318 26710 {lab=n_0773}
C {./lab_pin.sym} 2318 26710 0 0 {name=l1422_2 lab=n_0773}
N 2338 26730 2318 26730 {lab=n_0774}
C {./lab_pin.sym} 2318 26730 0 0 {name=l1422_3 lab=n_0774}
N 2522 26670 2542 26670 {lab=VDD}
C {./lab_pin.sym} 2542 26670 0 1 {name=l1422_4 lab=VDD}
N 2522 26690 2542 26690 {lab=VDD}
C {./lab_pin.sym} 2542 26690 0 1 {name=l1422_5 lab=VDD}
N 2522 26710 2542 26710 {lab=VSS}
C {./lab_pin.sym} 2542 26710 0 1 {name=l1422_6 lab=VSS}
N 2522 26730 2542 26730 {lab=VSS}
C {./lab_pin.sym} 2542 26730 0 1 {name=l1422_7 lab=VSS}
C {./xor3_1.sym} 2835 26700 0 0 {name=Xn_1364}
N 2743 26670 2723 26670 {lab=u_cas_int_out_int2_b4}
C {./lab_pin.sym} 2723 26670 0 0 {name=l1423_0 lab=u_cas_int_out_int2_b4}
N 2743 26690 2723 26690 {lab=u_cas_int_out_int1_b4}
C {./lab_pin.sym} 2723 26690 0 0 {name=l1423_1 lab=u_cas_int_out_int1_b4}
N 2743 26710 2723 26710 {lab=n_0770}
C {./lab_pin.sym} 2723 26710 0 0 {name=l1423_2 lab=n_0770}
N 2743 26730 2723 26730 {lab=n_0106}
C {./lab_pin.sym} 2723 26730 0 0 {name=l1423_3 lab=n_0106}
N 2927 26670 2947 26670 {lab=VDD}
C {./lab_pin.sym} 2947 26670 0 1 {name=l1423_4 lab=VDD}
N 2927 26690 2947 26690 {lab=VDD}
C {./lab_pin.sym} 2947 26690 0 1 {name=l1423_5 lab=VDD}
N 2927 26710 2947 26710 {lab=VSS}
C {./lab_pin.sym} 2947 26710 0 1 {name=l1423_6 lab=VSS}
N 2927 26730 2947 26730 {lab=VSS}
C {./lab_pin.sym} 2947 26730 0 1 {name=l1423_7 lab=VSS}
C {./nand2_1.sym} 3240 26700 0 0 {name=Xn_1365}
N 3148 26670 3128 26670 {lab=n_0772}
C {./lab_pin.sym} 3128 26670 0 0 {name=l1424_0 lab=n_0772}
N 3148 26690 3128 26690 {lab=n_0774}
C {./lab_pin.sym} 3128 26690 0 0 {name=l1424_1 lab=n_0774}
N 3148 26710 3128 26710 {lab=n_0775}
C {./lab_pin.sym} 3128 26710 0 0 {name=l1424_2 lab=n_0775}
N 3148 26730 3128 26730 {lab=VDD}
C {./lab_pin.sym} 3128 26730 0 0 {name=l1424_3 lab=VDD}
N 3332 26680 3352 26680 {lab=VDD}
C {./lab_pin.sym} 3352 26680 0 1 {name=l1424_4 lab=VDD}
N 3332 26700 3352 26700 {lab=VSS}
C {./lab_pin.sym} 3352 26700 0 1 {name=l1424_5 lab=VSS}
N 3332 26720 3352 26720 {lab=VSS}
C {./lab_pin.sym} 3352 26720 0 1 {name=l1424_6 lab=VSS}
C {./nor2_1.sym} 3645 26700 0 0 {name=Xn_1366}
N 3553 26670 3533 26670 {lab=u_cas_int_out_int2_b5}
C {./lab_pin.sym} 3533 26670 0 0 {name=l1425_0 lab=u_cas_int_out_int2_b5}
N 3553 26690 3533 26690 {lab=u_cas_int_out_int1_b5}
C {./lab_pin.sym} 3533 26690 0 0 {name=l1425_1 lab=u_cas_int_out_int1_b5}
N 3553 26710 3533 26710 {lab=n_0776}
C {./lab_pin.sym} 3533 26710 0 0 {name=l1425_2 lab=n_0776}
N 3553 26730 3533 26730 {lab=VDD}
C {./lab_pin.sym} 3533 26730 0 0 {name=l1425_3 lab=VDD}
N 3737 26680 3757 26680 {lab=VDD}
C {./lab_pin.sym} 3757 26680 0 1 {name=l1425_4 lab=VDD}
N 3737 26700 3757 26700 {lab=VSS}
C {./lab_pin.sym} 3757 26700 0 1 {name=l1425_5 lab=VSS}
N 3737 26720 3757 26720 {lab=VSS}
C {./lab_pin.sym} 3757 26720 0 1 {name=l1425_6 lab=VSS}
C {./nand2_1.sym} 4050 26700 0 0 {name=Xn_1367}
N 3958 26670 3938 26670 {lab=u_cas_int_out_int2_b5}
C {./lab_pin.sym} 3938 26670 0 0 {name=l1426_0 lab=u_cas_int_out_int2_b5}
N 3958 26690 3938 26690 {lab=u_cas_int_out_int1_b5}
C {./lab_pin.sym} 3938 26690 0 0 {name=l1426_1 lab=u_cas_int_out_int1_b5}
N 3958 26710 3938 26710 {lab=n_0777}
C {./lab_pin.sym} 3938 26710 0 0 {name=l1426_2 lab=n_0777}
N 3958 26730 3938 26730 {lab=VDD}
C {./lab_pin.sym} 3938 26730 0 0 {name=l1426_3 lab=VDD}
N 4142 26680 4162 26680 {lab=VDD}
C {./lab_pin.sym} 4162 26680 0 1 {name=l1426_4 lab=VDD}
N 4142 26700 4162 26700 {lab=VSS}
C {./lab_pin.sym} 4162 26700 0 1 {name=l1426_5 lab=VSS}
N 4142 26720 4162 26720 {lab=VSS}
C {./lab_pin.sym} 4162 26720 0 1 {name=l1426_6 lab=VSS}
C {./xor3_1.sym} 4455 26700 0 0 {name=Xn_1368}
N 4363 26670 4343 26670 {lab=u_cas_int_out_int2_b5}
C {./lab_pin.sym} 4343 26670 0 0 {name=l1427_0 lab=u_cas_int_out_int2_b5}
N 4363 26690 4343 26690 {lab=u_cas_int_out_int1_b5}
C {./lab_pin.sym} 4343 26690 0 0 {name=l1427_1 lab=u_cas_int_out_int1_b5}
N 4363 26710 4343 26710 {lab=n_0775}
C {./lab_pin.sym} 4343 26710 0 0 {name=l1427_2 lab=n_0775}
N 4363 26730 4343 26730 {lab=n_0107}
C {./lab_pin.sym} 4343 26730 0 0 {name=l1427_3 lab=n_0107}
N 4547 26670 4567 26670 {lab=VDD}
C {./lab_pin.sym} 4567 26670 0 1 {name=l1427_4 lab=VDD}
N 4547 26690 4567 26690 {lab=VDD}
C {./lab_pin.sym} 4567 26690 0 1 {name=l1427_5 lab=VDD}
N 4547 26710 4567 26710 {lab=VSS}
C {./lab_pin.sym} 4567 26710 0 1 {name=l1427_6 lab=VSS}
N 4547 26730 4567 26730 {lab=VSS}
C {./lab_pin.sym} 4567 26730 0 1 {name=l1427_7 lab=VSS}
C {./or2_1.sym} 0 26925 0 0 {name=Xn_1369}
N -92 26895 -112 26895 {lab=u_cas_int_out_int2_b6}
C {./lab_pin.sym} -112 26895 0 0 {name=l1428_0 lab=u_cas_int_out_int2_b6}
N -92 26915 -112 26915 {lab=u_cas_int_out_int1_b6}
C {./lab_pin.sym} -112 26915 0 0 {name=l1428_1 lab=u_cas_int_out_int1_b6}
N -92 26935 -112 26935 {lab=n_0778}
C {./lab_pin.sym} -112 26935 0 0 {name=l1428_2 lab=n_0778}
N -92 26955 -112 26955 {lab=VDD}
C {./lab_pin.sym} -112 26955 0 0 {name=l1428_3 lab=VDD}
N 92 26905 112 26905 {lab=VDD}
C {./lab_pin.sym} 112 26905 0 1 {name=l1428_4 lab=VDD}
N 92 26925 112 26925 {lab=VSS}
C {./lab_pin.sym} 112 26925 0 1 {name=l1428_5 lab=VSS}
N 92 26945 112 26945 {lab=VSS}
C {./lab_pin.sym} 112 26945 0 1 {name=l1428_6 lab=VSS}
C {./and2_1.sym} 405 26925 0 0 {name=Xn_1370}
N 313 26895 293 26895 {lab=u_cas_int_out_int2_b6}
C {./lab_pin.sym} 293 26895 0 0 {name=l1429_0 lab=u_cas_int_out_int2_b6}
N 313 26915 293 26915 {lab=u_cas_int_out_int1_b6}
C {./lab_pin.sym} 293 26915 0 0 {name=l1429_1 lab=u_cas_int_out_int1_b6}
N 313 26935 293 26935 {lab=n_0779}
C {./lab_pin.sym} 293 26935 0 0 {name=l1429_2 lab=n_0779}
N 313 26955 293 26955 {lab=VDD}
C {./lab_pin.sym} 293 26955 0 0 {name=l1429_3 lab=VDD}
N 497 26905 517 26905 {lab=VDD}
C {./lab_pin.sym} 517 26905 0 1 {name=l1429_4 lab=VDD}
N 497 26925 517 26925 {lab=VSS}
C {./lab_pin.sym} 517 26925 0 1 {name=l1429_5 lab=VSS}
N 497 26945 517 26945 {lab=VSS}
C {./lab_pin.sym} 517 26945 0 1 {name=l1429_6 lab=VSS}
C {./aoi22_1.sym} 810 26925 0 0 {name=Xn_1371}
N 718 26885 698 26885 {lab=u_cas_int_out_int2_b4}
C {./lab_pin.sym} 698 26885 0 0 {name=l1430_0 lab=u_cas_int_out_int2_b4}
N 718 26905 698 26905 {lab=u_cas_int_out_int1_b4}
C {./lab_pin.sym} 698 26905 0 0 {name=l1430_1 lab=u_cas_int_out_int1_b4}
N 718 26925 698 26925 {lab=u_cas_int_out_int1_b5}
C {./lab_pin.sym} 698 26925 0 0 {name=l1430_2 lab=u_cas_int_out_int1_b5}
N 718 26945 698 26945 {lab=u_cas_int_out_int2_b5}
C {./lab_pin.sym} 698 26945 0 0 {name=l1430_3 lab=u_cas_int_out_int2_b5}
N 718 26965 698 26965 {lab=n_0780}
C {./lab_pin.sym} 698 26965 0 0 {name=l1430_4 lab=n_0780}
N 902 26895 922 26895 {lab=VDD}
C {./lab_pin.sym} 922 26895 0 1 {name=l1430_5 lab=VDD}
N 902 26915 922 26915 {lab=VDD}
C {./lab_pin.sym} 922 26915 0 1 {name=l1430_6 lab=VDD}
N 902 26935 922 26935 {lab=VSS}
C {./lab_pin.sym} 922 26935 0 1 {name=l1430_7 lab=VSS}
N 902 26955 922 26955 {lab=VSS}
C {./lab_pin.sym} 922 26955 0 1 {name=l1430_8 lab=VSS}
C {./aoi21_1.sym} 1215 26925 0 0 {name=Xn_1372}
N 1123 26895 1103 26895 {lab=n_0772}
C {./lab_pin.sym} 1103 26895 0 0 {name=l1431_0 lab=n_0772}
N 1123 26915 1103 26915 {lab=n_0777}
C {./lab_pin.sym} 1103 26915 0 0 {name=l1431_1 lab=n_0777}
N 1123 26935 1103 26935 {lab=n_0776}
C {./lab_pin.sym} 1103 26935 0 0 {name=l1431_2 lab=n_0776}
N 1123 26955 1103 26955 {lab=n_0781}
C {./lab_pin.sym} 1103 26955 0 0 {name=l1431_3 lab=n_0781}
N 1307 26895 1327 26895 {lab=VDD}
C {./lab_pin.sym} 1327 26895 0 1 {name=l1431_4 lab=VDD}
N 1307 26915 1327 26915 {lab=VDD}
C {./lab_pin.sym} 1327 26915 0 1 {name=l1431_5 lab=VDD}
N 1307 26935 1327 26935 {lab=VSS}
C {./lab_pin.sym} 1327 26935 0 1 {name=l1431_6 lab=VSS}
N 1307 26955 1327 26955 {lab=VSS}
C {./lab_pin.sym} 1327 26955 0 1 {name=l1431_7 lab=VSS}
C {./aoi21_1.sym} 1620 26925 0 0 {name=Xn_1373}
N 1528 26895 1508 26895 {lab=n_0774}
C {./lab_pin.sym} 1508 26895 0 0 {name=l1432_0 lab=n_0774}
N 1528 26915 1508 26915 {lab=n_0780}
C {./lab_pin.sym} 1508 26915 0 0 {name=l1432_1 lab=n_0780}
N 1528 26935 1508 26935 {lab=n_0776}
C {./lab_pin.sym} 1508 26935 0 0 {name=l1432_2 lab=n_0776}
N 1528 26955 1508 26955 {lab=n_0782}
C {./lab_pin.sym} 1508 26955 0 0 {name=l1432_3 lab=n_0782}
N 1712 26895 1732 26895 {lab=VDD}
C {./lab_pin.sym} 1732 26895 0 1 {name=l1432_4 lab=VDD}
N 1712 26915 1732 26915 {lab=VDD}
C {./lab_pin.sym} 1732 26915 0 1 {name=l1432_5 lab=VDD}
N 1712 26935 1732 26935 {lab=VSS}
C {./lab_pin.sym} 1732 26935 0 1 {name=l1432_6 lab=VSS}
N 1712 26955 1732 26955 {lab=VSS}
C {./lab_pin.sym} 1732 26955 0 1 {name=l1432_7 lab=VSS}
C {./xor3_1.sym} 2025 26925 0 0 {name=Xn_1374}
N 1933 26895 1913 26895 {lab=u_cas_int_out_int2_b6}
C {./lab_pin.sym} 1913 26895 0 0 {name=l1433_0 lab=u_cas_int_out_int2_b6}
N 1933 26915 1913 26915 {lab=u_cas_int_out_int1_b6}
C {./lab_pin.sym} 1913 26915 0 0 {name=l1433_1 lab=u_cas_int_out_int1_b6}
N 1933 26935 1913 26935 {lab=n_0782}
C {./lab_pin.sym} 1913 26935 0 0 {name=l1433_2 lab=n_0782}
N 1933 26955 1913 26955 {lab=n_0108}
C {./lab_pin.sym} 1913 26955 0 0 {name=l1433_3 lab=n_0108}
N 2117 26895 2137 26895 {lab=VDD}
C {./lab_pin.sym} 2137 26895 0 1 {name=l1433_4 lab=VDD}
N 2117 26915 2137 26915 {lab=VDD}
C {./lab_pin.sym} 2137 26915 0 1 {name=l1433_5 lab=VDD}
N 2117 26935 2137 26935 {lab=VSS}
C {./lab_pin.sym} 2137 26935 0 1 {name=l1433_6 lab=VSS}
N 2117 26955 2137 26955 {lab=VSS}
C {./lab_pin.sym} 2137 26955 0 1 {name=l1433_7 lab=VSS}
C {./aoi21_1.sym} 2430 26925 0 0 {name=Xn_1375}
N 2338 26895 2318 26895 {lab=n_0782}
C {./lab_pin.sym} 2318 26895 0 0 {name=l1434_0 lab=n_0782}
N 2338 26915 2318 26915 {lab=n_0778}
C {./lab_pin.sym} 2318 26915 0 0 {name=l1434_1 lab=n_0778}
N 2338 26935 2318 26935 {lab=n_0779}
C {./lab_pin.sym} 2318 26935 0 0 {name=l1434_2 lab=n_0779}
N 2338 26955 2318 26955 {lab=n_0783}
C {./lab_pin.sym} 2318 26955 0 0 {name=l1434_3 lab=n_0783}
N 2522 26895 2542 26895 {lab=VDD}
C {./lab_pin.sym} 2542 26895 0 1 {name=l1434_4 lab=VDD}
N 2522 26915 2542 26915 {lab=VDD}
C {./lab_pin.sym} 2542 26915 0 1 {name=l1434_5 lab=VDD}
N 2522 26935 2542 26935 {lab=VSS}
C {./lab_pin.sym} 2542 26935 0 1 {name=l1434_6 lab=VSS}
N 2522 26955 2542 26955 {lab=VSS}
C {./lab_pin.sym} 2542 26955 0 1 {name=l1434_7 lab=VSS}
C {./and2_1.sym} 2835 26925 0 0 {name=Xn_1376}
N 2743 26895 2723 26895 {lab=u_cas_int_out_int2_b7}
C {./lab_pin.sym} 2723 26895 0 0 {name=l1435_0 lab=u_cas_int_out_int2_b7}
N 2743 26915 2723 26915 {lab=u_cas_int_out_int1_b7}
C {./lab_pin.sym} 2723 26915 0 0 {name=l1435_1 lab=u_cas_int_out_int1_b7}
N 2743 26935 2723 26935 {lab=n_0784}
C {./lab_pin.sym} 2723 26935 0 0 {name=l1435_2 lab=n_0784}
N 2743 26955 2723 26955 {lab=VDD}
C {./lab_pin.sym} 2723 26955 0 0 {name=l1435_3 lab=VDD}
N 2927 26905 2947 26905 {lab=VDD}
C {./lab_pin.sym} 2947 26905 0 1 {name=l1435_4 lab=VDD}
N 2927 26925 2947 26925 {lab=VSS}
C {./lab_pin.sym} 2947 26925 0 1 {name=l1435_5 lab=VSS}
N 2927 26945 2947 26945 {lab=VSS}
C {./lab_pin.sym} 2947 26945 0 1 {name=l1435_6 lab=VSS}
C {./nand2_1.sym} 3240 26925 0 0 {name=Xn_1377}
N 3148 26895 3128 26895 {lab=u_cas_int_out_int2_b7}
C {./lab_pin.sym} 3128 26895 0 0 {name=l1436_0 lab=u_cas_int_out_int2_b7}
N 3148 26915 3128 26915 {lab=u_cas_int_out_int1_b7}
C {./lab_pin.sym} 3128 26915 0 0 {name=l1436_1 lab=u_cas_int_out_int1_b7}
N 3148 26935 3128 26935 {lab=n_0785}
C {./lab_pin.sym} 3128 26935 0 0 {name=l1436_2 lab=n_0785}
N 3148 26955 3128 26955 {lab=VDD}
C {./lab_pin.sym} 3128 26955 0 0 {name=l1436_3 lab=VDD}
N 3332 26905 3352 26905 {lab=VDD}
C {./lab_pin.sym} 3352 26905 0 1 {name=l1436_4 lab=VDD}
N 3332 26925 3352 26925 {lab=VSS}
C {./lab_pin.sym} 3352 26925 0 1 {name=l1436_5 lab=VSS}
N 3332 26945 3352 26945 {lab=VSS}
C {./lab_pin.sym} 3352 26945 0 1 {name=l1436_6 lab=VSS}
C {./xor3_1.sym} 3645 26925 0 0 {name=Xn_1378}
N 3553 26895 3533 26895 {lab=u_cas_int_out_int2_b7}
C {./lab_pin.sym} 3533 26895 0 0 {name=l1437_0 lab=u_cas_int_out_int2_b7}
N 3553 26915 3533 26915 {lab=n_0498}
C {./lab_pin.sym} 3533 26915 0 0 {name=l1437_1 lab=n_0498}
N 3553 26935 3533 26935 {lab=n_0783}
C {./lab_pin.sym} 3533 26935 0 0 {name=l1437_2 lab=n_0783}
N 3553 26955 3533 26955 {lab=n_0109}
C {./lab_pin.sym} 3533 26955 0 0 {name=l1437_3 lab=n_0109}
N 3737 26895 3757 26895 {lab=VDD}
C {./lab_pin.sym} 3757 26895 0 1 {name=l1437_4 lab=VDD}
N 3737 26915 3757 26915 {lab=VDD}
C {./lab_pin.sym} 3757 26915 0 1 {name=l1437_5 lab=VDD}
N 3737 26935 3757 26935 {lab=VSS}
C {./lab_pin.sym} 3757 26935 0 1 {name=l1437_6 lab=VSS}
N 3737 26955 3757 26955 {lab=VSS}
C {./lab_pin.sym} 3757 26955 0 1 {name=l1437_7 lab=VSS}
C {./oai22_1.sym} 4050 26925 0 0 {name=Xn_1379}
N 3958 26885 3938 26885 {lab=u_cas_int_out_int2_b6}
C {./lab_pin.sym} 3938 26885 0 0 {name=l1438_0 lab=u_cas_int_out_int2_b6}
N 3958 26905 3938 26905 {lab=u_cas_int_out_int1_b6}
C {./lab_pin.sym} 3938 26905 0 0 {name=l1438_1 lab=u_cas_int_out_int1_b6}
N 3958 26925 3938 26925 {lab=u_cas_int_out_int1_b7}
C {./lab_pin.sym} 3938 26925 0 0 {name=l1438_2 lab=u_cas_int_out_int1_b7}
N 3958 26945 3938 26945 {lab=u_cas_int_out_int2_b7}
C {./lab_pin.sym} 3938 26945 0 0 {name=l1438_3 lab=u_cas_int_out_int2_b7}
N 3958 26965 3938 26965 {lab=n_0786}
C {./lab_pin.sym} 3938 26965 0 0 {name=l1438_4 lab=n_0786}
N 4142 26895 4162 26895 {lab=VDD}
C {./lab_pin.sym} 4162 26895 0 1 {name=l1438_5 lab=VDD}
N 4142 26915 4162 26915 {lab=VDD}
C {./lab_pin.sym} 4162 26915 0 1 {name=l1438_6 lab=VDD}
N 4142 26935 4162 26935 {lab=VSS}
C {./lab_pin.sym} 4162 26935 0 1 {name=l1438_7 lab=VSS}
N 4142 26955 4162 26955 {lab=VSS}
C {./lab_pin.sym} 4162 26955 0 1 {name=l1438_8 lab=VSS}
C {./nor3_1.sym} 4455 26925 0 0 {name=Xn_1380}
N 4363 26895 4343 26895 {lab=n_0786}
C {./lab_pin.sym} 4343 26895 0 0 {name=l1439_0 lab=n_0786}
N 4363 26915 4343 26915 {lab=n_0784}
C {./lab_pin.sym} 4343 26915 0 0 {name=l1439_1 lab=n_0784}
N 4363 26935 4343 26935 {lab=n_0779}
C {./lab_pin.sym} 4343 26935 0 0 {name=l1439_2 lab=n_0779}
N 4363 26955 4343 26955 {lab=n_0787}
C {./lab_pin.sym} 4343 26955 0 0 {name=l1439_3 lab=n_0787}
N 4547 26895 4567 26895 {lab=VDD}
C {./lab_pin.sym} 4567 26895 0 1 {name=l1439_4 lab=VDD}
N 4547 26915 4567 26915 {lab=VDD}
C {./lab_pin.sym} 4567 26915 0 1 {name=l1439_5 lab=VDD}
N 4547 26935 4567 26935 {lab=VSS}
C {./lab_pin.sym} 4567 26935 0 1 {name=l1439_6 lab=VSS}
N 4547 26955 4567 26955 {lab=VSS}
C {./lab_pin.sym} 4567 26955 0 1 {name=l1439_7 lab=VSS}
C {./oai22_1.sym} 0 27150 0 0 {name=Xn_1381}
N -92 27110 -112 27110 {lab=u_cas_int_out_int2_b4}
C {./lab_pin.sym} -112 27110 0 0 {name=l1440_0 lab=u_cas_int_out_int2_b4}
N -92 27130 -112 27130 {lab=u_cas_int_out_int1_b4}
C {./lab_pin.sym} -112 27130 0 0 {name=l1440_1 lab=u_cas_int_out_int1_b4}
N -92 27150 -112 27150 {lab=u_cas_int_out_int1_b5}
C {./lab_pin.sym} -112 27150 0 0 {name=l1440_2 lab=u_cas_int_out_int1_b5}
N -92 27170 -112 27170 {lab=u_cas_int_out_int2_b5}
C {./lab_pin.sym} -112 27170 0 0 {name=l1440_3 lab=u_cas_int_out_int2_b5}
N -92 27190 -112 27190 {lab=n_0788}
C {./lab_pin.sym} -112 27190 0 0 {name=l1440_4 lab=n_0788}
N 92 27120 112 27120 {lab=VDD}
C {./lab_pin.sym} 112 27120 0 1 {name=l1440_5 lab=VDD}
N 92 27140 112 27140 {lab=VDD}
C {./lab_pin.sym} 112 27140 0 1 {name=l1440_6 lab=VDD}
N 92 27160 112 27160 {lab=VSS}
C {./lab_pin.sym} 112 27160 0 1 {name=l1440_7 lab=VSS}
N 92 27180 112 27180 {lab=VSS}
C {./lab_pin.sym} 112 27180 0 1 {name=l1440_8 lab=VSS}
C {./aoi21_1.sym} 405 27150 0 0 {name=Xn_1382}
N 313 27120 293 27120 {lab=u_cas_int_out_int2_b4}
C {./lab_pin.sym} 293 27120 0 0 {name=l1441_0 lab=u_cas_int_out_int2_b4}
N 313 27140 293 27140 {lab=u_cas_int_out_int1_b4}
C {./lab_pin.sym} 293 27140 0 0 {name=l1441_1 lab=u_cas_int_out_int1_b4}
N 313 27160 293 27160 {lab=n_0788}
C {./lab_pin.sym} 293 27160 0 0 {name=l1441_2 lab=n_0788}
N 313 27180 293 27180 {lab=n_0789}
C {./lab_pin.sym} 293 27180 0 0 {name=l1441_3 lab=n_0789}
N 497 27120 517 27120 {lab=VDD}
C {./lab_pin.sym} 517 27120 0 1 {name=l1441_4 lab=VDD}
N 497 27140 517 27140 {lab=VDD}
C {./lab_pin.sym} 517 27140 0 1 {name=l1441_5 lab=VDD}
N 497 27160 517 27160 {lab=VSS}
C {./lab_pin.sym} 517 27160 0 1 {name=l1441_6 lab=VSS}
N 497 27180 517 27180 {lab=VSS}
C {./lab_pin.sym} 517 27180 0 1 {name=l1441_7 lab=VSS}
C {./nand3_1.sym} 810 27150 0 0 {name=Xn_1383}
N 718 27120 698 27120 {lab=n_0787}
C {./lab_pin.sym} 698 27120 0 0 {name=l1442_0 lab=n_0787}
N 718 27140 698 27140 {lab=n_0789}
C {./lab_pin.sym} 698 27140 0 0 {name=l1442_1 lab=n_0789}
N 718 27160 698 27160 {lab=n_0777}
C {./lab_pin.sym} 698 27160 0 0 {name=l1442_2 lab=n_0777}
N 718 27180 698 27180 {lab=n_0790}
C {./lab_pin.sym} 698 27180 0 0 {name=l1442_3 lab=n_0790}
N 902 27120 922 27120 {lab=VDD}
C {./lab_pin.sym} 922 27120 0 1 {name=l1442_4 lab=VDD}
N 902 27140 922 27140 {lab=VDD}
C {./lab_pin.sym} 922 27140 0 1 {name=l1442_5 lab=VDD}
N 902 27160 922 27160 {lab=VSS}
C {./lab_pin.sym} 922 27160 0 1 {name=l1442_6 lab=VSS}
N 902 27180 922 27180 {lab=VSS}
C {./lab_pin.sym} 922 27180 0 1 {name=l1442_7 lab=VSS}
C {./oai211_1.sym} 1215 27150 0 0 {name=Xn_1384}
N 1123 27110 1103 27110 {lab=u_cas_int_out_int2_b7}
C {./lab_pin.sym} 1103 27110 0 0 {name=l1443_0 lab=u_cas_int_out_int2_b7}
N 1123 27130 1103 27130 {lab=u_cas_int_out_int1_b7}
C {./lab_pin.sym} 1103 27130 0 0 {name=l1443_1 lab=u_cas_int_out_int1_b7}
N 1123 27150 1103 27150 {lab=u_cas_int_out_int1_b6}
C {./lab_pin.sym} 1103 27150 0 0 {name=l1443_2 lab=u_cas_int_out_int1_b6}
N 1123 27170 1103 27170 {lab=u_cas_int_out_int2_b6}
C {./lab_pin.sym} 1103 27170 0 0 {name=l1443_3 lab=u_cas_int_out_int2_b6}
N 1123 27190 1103 27190 {lab=n_0791}
C {./lab_pin.sym} 1103 27190 0 0 {name=l1443_4 lab=n_0791}
N 1307 27120 1327 27120 {lab=VDD}
C {./lab_pin.sym} 1327 27120 0 1 {name=l1443_5 lab=VDD}
N 1307 27140 1327 27140 {lab=VDD}
C {./lab_pin.sym} 1327 27140 0 1 {name=l1443_6 lab=VDD}
N 1307 27160 1327 27160 {lab=VSS}
C {./lab_pin.sym} 1327 27160 0 1 {name=l1443_7 lab=VSS}
N 1307 27180 1327 27180 {lab=VSS}
C {./lab_pin.sym} 1327 27180 0 1 {name=l1443_8 lab=VSS}
C {./nand2_1.sym} 1620 27150 0 0 {name=Xn_1385}
N 1528 27120 1508 27120 {lab=n_0785}
C {./lab_pin.sym} 1508 27120 0 0 {name=l1444_0 lab=n_0785}
N 1528 27140 1508 27140 {lab=n_0791}
C {./lab_pin.sym} 1508 27140 0 0 {name=l1444_1 lab=n_0791}
N 1528 27160 1508 27160 {lab=n_0792}
C {./lab_pin.sym} 1508 27160 0 0 {name=l1444_2 lab=n_0792}
N 1528 27180 1508 27180 {lab=VDD}
C {./lab_pin.sym} 1508 27180 0 0 {name=l1444_3 lab=VDD}
N 1712 27130 1732 27130 {lab=VDD}
C {./lab_pin.sym} 1732 27130 0 1 {name=l1444_4 lab=VDD}
N 1712 27150 1732 27150 {lab=VSS}
C {./lab_pin.sym} 1732 27150 0 1 {name=l1444_5 lab=VSS}
N 1712 27170 1732 27170 {lab=VSS}
C {./lab_pin.sym} 1732 27170 0 1 {name=l1444_6 lab=VSS}
C {./aoi21_1.sym} 2025 27150 0 0 {name=Xn_1386}
N 1933 27120 1913 27120 {lab=n_0787}
C {./lab_pin.sym} 1913 27120 0 0 {name=l1445_0 lab=n_0787}
N 1933 27140 1913 27140 {lab=n_0781}
C {./lab_pin.sym} 1913 27140 0 0 {name=l1445_1 lab=n_0781}
N 1933 27160 1913 27160 {lab=n_0792}
C {./lab_pin.sym} 1913 27160 0 0 {name=l1445_2 lab=n_0792}
N 1933 27180 1913 27180 {lab=n_0793}
C {./lab_pin.sym} 1913 27180 0 0 {name=l1445_3 lab=n_0793}
N 2117 27120 2137 27120 {lab=VDD}
C {./lab_pin.sym} 2137 27120 0 1 {name=l1445_4 lab=VDD}
N 2117 27140 2137 27140 {lab=VDD}
C {./lab_pin.sym} 2137 27140 0 1 {name=l1445_5 lab=VDD}
N 2117 27160 2137 27160 {lab=VSS}
C {./lab_pin.sym} 2137 27160 0 1 {name=l1445_6 lab=VSS}
N 2117 27180 2137 27180 {lab=VSS}
C {./lab_pin.sym} 2137 27180 0 1 {name=l1445_7 lab=VSS}
C {./oai21_1.sym} 2430 27150 0 0 {name=Xn_1387}
N 2338 27120 2318 27120 {lab=n_0771}
C {./lab_pin.sym} 2318 27120 0 0 {name=l1446_0 lab=n_0771}
N 2338 27140 2318 27140 {lab=n_0790}
C {./lab_pin.sym} 2318 27140 0 0 {name=l1446_1 lab=n_0790}
N 2338 27160 2318 27160 {lab=n_0793}
C {./lab_pin.sym} 2318 27160 0 0 {name=l1446_2 lab=n_0793}
N 2338 27180 2318 27180 {lab=n_0794}
C {./lab_pin.sym} 2318 27180 0 0 {name=l1446_3 lab=n_0794}
N 2522 27120 2542 27120 {lab=VDD}
C {./lab_pin.sym} 2542 27120 0 1 {name=l1446_4 lab=VDD}
N 2522 27140 2542 27140 {lab=VDD}
C {./lab_pin.sym} 2542 27140 0 1 {name=l1446_5 lab=VDD}
N 2522 27160 2542 27160 {lab=VSS}
C {./lab_pin.sym} 2542 27160 0 1 {name=l1446_6 lab=VSS}
N 2522 27180 2542 27180 {lab=VSS}
C {./lab_pin.sym} 2542 27180 0 1 {name=l1446_7 lab=VSS}
C {./nand2_1.sym} 2835 27150 0 0 {name=Xn_1388}
N 2743 27120 2723 27120 {lab=u_cas_int_out_int2_b8}
C {./lab_pin.sym} 2723 27120 0 0 {name=l1447_0 lab=u_cas_int_out_int2_b8}
N 2743 27140 2723 27140 {lab=u_cas_int_out_int1_b8}
C {./lab_pin.sym} 2723 27140 0 0 {name=l1447_1 lab=u_cas_int_out_int1_b8}
N 2743 27160 2723 27160 {lab=n_0795}
C {./lab_pin.sym} 2723 27160 0 0 {name=l1447_2 lab=n_0795}
N 2743 27180 2723 27180 {lab=VDD}
C {./lab_pin.sym} 2723 27180 0 0 {name=l1447_3 lab=VDD}
N 2927 27130 2947 27130 {lab=VDD}
C {./lab_pin.sym} 2947 27130 0 1 {name=l1447_4 lab=VDD}
N 2927 27150 2947 27150 {lab=VSS}
C {./lab_pin.sym} 2947 27150 0 1 {name=l1447_5 lab=VSS}
N 2927 27170 2947 27170 {lab=VSS}
C {./lab_pin.sym} 2947 27170 0 1 {name=l1447_6 lab=VSS}
C {./or2_1.sym} 3240 27150 0 0 {name=Xn_1389}
N 3148 27120 3128 27120 {lab=u_cas_int_out_int2_b8}
C {./lab_pin.sym} 3128 27120 0 0 {name=l1448_0 lab=u_cas_int_out_int2_b8}
N 3148 27140 3128 27140 {lab=u_cas_int_out_int1_b8}
C {./lab_pin.sym} 3128 27140 0 0 {name=l1448_1 lab=u_cas_int_out_int1_b8}
N 3148 27160 3128 27160 {lab=n_0796}
C {./lab_pin.sym} 3128 27160 0 0 {name=l1448_2 lab=n_0796}
N 3148 27180 3128 27180 {lab=VDD}
C {./lab_pin.sym} 3128 27180 0 0 {name=l1448_3 lab=VDD}
N 3332 27130 3352 27130 {lab=VDD}
C {./lab_pin.sym} 3352 27130 0 1 {name=l1448_4 lab=VDD}
N 3332 27150 3352 27150 {lab=VSS}
C {./lab_pin.sym} 3352 27150 0 1 {name=l1448_5 lab=VSS}
N 3332 27170 3352 27170 {lab=VSS}
C {./lab_pin.sym} 3352 27170 0 1 {name=l1448_6 lab=VSS}
C {./nand3_1.sym} 3645 27150 0 0 {name=Xn_1390}
N 3553 27120 3533 27120 {lab=n_0794}
C {./lab_pin.sym} 3533 27120 0 0 {name=l1449_0 lab=n_0794}
N 3553 27140 3533 27140 {lab=n_0795}
C {./lab_pin.sym} 3533 27140 0 0 {name=l1449_1 lab=n_0795}
N 3553 27160 3533 27160 {lab=n_0796}
C {./lab_pin.sym} 3533 27160 0 0 {name=l1449_2 lab=n_0796}
N 3553 27180 3533 27180 {lab=n_0797}
C {./lab_pin.sym} 3533 27180 0 0 {name=l1449_3 lab=n_0797}
N 3737 27120 3757 27120 {lab=VDD}
C {./lab_pin.sym} 3757 27120 0 1 {name=l1449_4 lab=VDD}
N 3737 27140 3757 27140 {lab=VDD}
C {./lab_pin.sym} 3757 27140 0 1 {name=l1449_5 lab=VDD}
N 3737 27160 3757 27160 {lab=VSS}
C {./lab_pin.sym} 3757 27160 0 1 {name=l1449_6 lab=VSS}
N 3737 27180 3757 27180 {lab=VSS}
C {./lab_pin.sym} 3757 27180 0 1 {name=l1449_7 lab=VSS}
C {./xor3_1.sym} 4050 27150 0 0 {name=Xn_1391}
N 3958 27120 3938 27120 {lab=u_cas_int_out_int2_b8}
C {./lab_pin.sym} 3938 27120 0 0 {name=l1450_0 lab=u_cas_int_out_int2_b8}
N 3958 27140 3938 27140 {lab=u_cas_int_out_int1_b8}
C {./lab_pin.sym} 3938 27140 0 0 {name=l1450_1 lab=u_cas_int_out_int1_b8}
N 3958 27160 3938 27160 {lab=n_0794}
C {./lab_pin.sym} 3938 27160 0 0 {name=l1450_2 lab=n_0794}
N 3958 27180 3938 27180 {lab=n_0110}
C {./lab_pin.sym} 3938 27180 0 0 {name=l1450_3 lab=n_0110}
N 4142 27120 4162 27120 {lab=VDD}
C {./lab_pin.sym} 4162 27120 0 1 {name=l1450_4 lab=VDD}
N 4142 27140 4162 27140 {lab=VDD}
C {./lab_pin.sym} 4162 27140 0 1 {name=l1450_5 lab=VDD}
N 4142 27160 4162 27160 {lab=VSS}
C {./lab_pin.sym} 4162 27160 0 1 {name=l1450_6 lab=VSS}
N 4142 27180 4162 27180 {lab=VSS}
C {./lab_pin.sym} 4162 27180 0 1 {name=l1450_7 lab=VSS}
C {./nand2_1.sym} 4455 27150 0 0 {name=Xn_1392}
N 4363 27120 4343 27120 {lab=n_0795}
C {./lab_pin.sym} 4343 27120 0 0 {name=l1451_0 lab=n_0795}
N 4363 27140 4343 27140 {lab=n_0797}
C {./lab_pin.sym} 4343 27140 0 0 {name=l1451_1 lab=n_0797}
N 4363 27160 4343 27160 {lab=n_0798}
C {./lab_pin.sym} 4343 27160 0 0 {name=l1451_2 lab=n_0798}
N 4363 27180 4343 27180 {lab=VDD}
C {./lab_pin.sym} 4343 27180 0 0 {name=l1451_3 lab=VDD}
N 4547 27130 4567 27130 {lab=VDD}
C {./lab_pin.sym} 4567 27130 0 1 {name=l1451_4 lab=VDD}
N 4547 27150 4567 27150 {lab=VSS}
C {./lab_pin.sym} 4567 27150 0 1 {name=l1451_5 lab=VSS}
N 4547 27170 4567 27170 {lab=VSS}
C {./lab_pin.sym} 4567 27170 0 1 {name=l1451_6 lab=VSS}
C {./or2_1.sym} 0 27375 0 0 {name=Xn_1393}
N -92 27345 -112 27345 {lab=u_cas_int_out_int2_b9}
C {./lab_pin.sym} -112 27345 0 0 {name=l1452_0 lab=u_cas_int_out_int2_b9}
N -92 27365 -112 27365 {lab=u_cas_int_out_int1_b9}
C {./lab_pin.sym} -112 27365 0 0 {name=l1452_1 lab=u_cas_int_out_int1_b9}
N -92 27385 -112 27385 {lab=n_0799}
C {./lab_pin.sym} -112 27385 0 0 {name=l1452_2 lab=n_0799}
N -92 27405 -112 27405 {lab=VDD}
C {./lab_pin.sym} -112 27405 0 0 {name=l1452_3 lab=VDD}
N 92 27355 112 27355 {lab=VDD}
C {./lab_pin.sym} 112 27355 0 1 {name=l1452_4 lab=VDD}
N 92 27375 112 27375 {lab=VSS}
C {./lab_pin.sym} 112 27375 0 1 {name=l1452_5 lab=VSS}
N 92 27395 112 27395 {lab=VSS}
C {./lab_pin.sym} 112 27395 0 1 {name=l1452_6 lab=VSS}
C {./nand2_1.sym} 405 27375 0 0 {name=Xn_1394}
N 313 27345 293 27345 {lab=u_cas_int_out_int2_b9}
C {./lab_pin.sym} 293 27345 0 0 {name=l1453_0 lab=u_cas_int_out_int2_b9}
N 313 27365 293 27365 {lab=u_cas_int_out_int1_b9}
C {./lab_pin.sym} 293 27365 0 0 {name=l1453_1 lab=u_cas_int_out_int1_b9}
N 313 27385 293 27385 {lab=n_0800}
C {./lab_pin.sym} 293 27385 0 0 {name=l1453_2 lab=n_0800}
N 313 27405 293 27405 {lab=VDD}
C {./lab_pin.sym} 293 27405 0 0 {name=l1453_3 lab=VDD}
N 497 27355 517 27355 {lab=VDD}
C {./lab_pin.sym} 517 27355 0 1 {name=l1453_4 lab=VDD}
N 497 27375 517 27375 {lab=VSS}
C {./lab_pin.sym} 517 27375 0 1 {name=l1453_5 lab=VSS}
N 497 27395 517 27395 {lab=VSS}
C {./lab_pin.sym} 517 27395 0 1 {name=l1453_6 lab=VSS}
C {./xor3_1.sym} 810 27375 0 0 {name=Xn_1395}
N 718 27345 698 27345 {lab=u_cas_int_out_int2_b9}
C {./lab_pin.sym} 698 27345 0 0 {name=l1454_0 lab=u_cas_int_out_int2_b9}
N 718 27365 698 27365 {lab=u_cas_int_out_int1_b9}
C {./lab_pin.sym} 698 27365 0 0 {name=l1454_1 lab=u_cas_int_out_int1_b9}
N 718 27385 698 27385 {lab=n_0798}
C {./lab_pin.sym} 698 27385 0 0 {name=l1454_2 lab=n_0798}
N 718 27405 698 27405 {lab=n_0111}
C {./lab_pin.sym} 698 27405 0 0 {name=l1454_3 lab=n_0111}
N 902 27345 922 27345 {lab=VDD}
C {./lab_pin.sym} 922 27345 0 1 {name=l1454_4 lab=VDD}
N 902 27365 922 27365 {lab=VDD}
C {./lab_pin.sym} 922 27365 0 1 {name=l1454_5 lab=VDD}
N 902 27385 922 27385 {lab=VSS}
C {./lab_pin.sym} 922 27385 0 1 {name=l1454_6 lab=VSS}
N 902 27405 922 27405 {lab=VSS}
C {./lab_pin.sym} 922 27405 0 1 {name=l1454_7 lab=VSS}
C {./nand4_1.sym} 1215 27375 0 0 {name=Xn_1396}
N 1123 27335 1103 27335 {lab=n_0795}
C {./lab_pin.sym} 1103 27335 0 0 {name=l1455_0 lab=n_0795}
N 1123 27355 1103 27355 {lab=n_0796}
C {./lab_pin.sym} 1103 27355 0 0 {name=l1455_1 lab=n_0796}
N 1123 27375 1103 27375 {lab=n_0799}
C {./lab_pin.sym} 1103 27375 0 0 {name=l1455_2 lab=n_0799}
N 1123 27395 1103 27395 {lab=n_0800}
C {./lab_pin.sym} 1103 27395 0 0 {name=l1455_3 lab=n_0800}
N 1123 27415 1103 27415 {lab=n_0801}
C {./lab_pin.sym} 1103 27415 0 0 {name=l1455_4 lab=n_0801}
N 1307 27345 1327 27345 {lab=VDD}
C {./lab_pin.sym} 1327 27345 0 1 {name=l1455_5 lab=VDD}
N 1307 27365 1327 27365 {lab=VDD}
C {./lab_pin.sym} 1327 27365 0 1 {name=l1455_6 lab=VDD}
N 1307 27385 1327 27385 {lab=VSS}
C {./lab_pin.sym} 1327 27385 0 1 {name=l1455_7 lab=VSS}
N 1307 27405 1327 27405 {lab=VSS}
C {./lab_pin.sym} 1327 27405 0 1 {name=l1455_8 lab=VSS}
C {./clkinv_1.sym} 1620 27375 0 0 {name=Xn_1397}
N 1528 27355 1508 27355 {lab=n_0801}
C {./lab_pin.sym} 1508 27355 0 0 {name=l1456_0 lab=n_0801}
N 1528 27375 1508 27375 {lab=n_0802}
C {./lab_pin.sym} 1508 27375 0 0 {name=l1456_1 lab=n_0802}
N 1528 27395 1508 27395 {lab=VDD}
C {./lab_pin.sym} 1508 27395 0 0 {name=l1456_2 lab=VDD}
N 1712 27355 1732 27355 {lab=VDD}
C {./lab_pin.sym} 1732 27355 0 1 {name=l1456_3 lab=VDD}
N 1712 27375 1732 27375 {lab=VSS}
C {./lab_pin.sym} 1732 27375 0 1 {name=l1456_4 lab=VSS}
N 1712 27395 1732 27395 {lab=VSS}
C {./lab_pin.sym} 1732 27395 0 1 {name=l1456_5 lab=VSS}
C {./oai211_1.sym} 2025 27375 0 0 {name=Xn_1398}
N 1933 27335 1913 27335 {lab=u_cas_int_out_int2_b9}
C {./lab_pin.sym} 1913 27335 0 0 {name=l1457_0 lab=u_cas_int_out_int2_b9}
N 1933 27355 1913 27355 {lab=u_cas_int_out_int1_b9}
C {./lab_pin.sym} 1913 27355 0 0 {name=l1457_1 lab=u_cas_int_out_int1_b9}
N 1933 27375 1913 27375 {lab=u_cas_int_out_int1_b8}
C {./lab_pin.sym} 1913 27375 0 0 {name=l1457_2 lab=u_cas_int_out_int1_b8}
N 1933 27395 1913 27395 {lab=u_cas_int_out_int2_b8}
C {./lab_pin.sym} 1913 27395 0 0 {name=l1457_3 lab=u_cas_int_out_int2_b8}
N 1933 27415 1913 27415 {lab=n_0803}
C {./lab_pin.sym} 1913 27415 0 0 {name=l1457_4 lab=n_0803}
N 2117 27345 2137 27345 {lab=VDD}
C {./lab_pin.sym} 2137 27345 0 1 {name=l1457_5 lab=VDD}
N 2117 27365 2137 27365 {lab=VDD}
C {./lab_pin.sym} 2137 27365 0 1 {name=l1457_6 lab=VDD}
N 2117 27385 2137 27385 {lab=VSS}
C {./lab_pin.sym} 2137 27385 0 1 {name=l1457_7 lab=VSS}
N 2117 27405 2137 27405 {lab=VSS}
C {./lab_pin.sym} 2137 27405 0 1 {name=l1457_8 lab=VSS}
C {./nand2_1.sym} 2430 27375 0 0 {name=Xn_1399}
N 2338 27345 2318 27345 {lab=n_0800}
C {./lab_pin.sym} 2318 27345 0 0 {name=l1458_0 lab=n_0800}
N 2338 27365 2318 27365 {lab=n_0803}
C {./lab_pin.sym} 2318 27365 0 0 {name=l1458_1 lab=n_0803}
N 2338 27385 2318 27385 {lab=n_0804}
C {./lab_pin.sym} 2318 27385 0 0 {name=l1458_2 lab=n_0804}
N 2338 27405 2318 27405 {lab=VDD}
C {./lab_pin.sym} 2318 27405 0 0 {name=l1458_3 lab=VDD}
N 2522 27355 2542 27355 {lab=VDD}
C {./lab_pin.sym} 2542 27355 0 1 {name=l1458_4 lab=VDD}
N 2522 27375 2542 27375 {lab=VSS}
C {./lab_pin.sym} 2542 27375 0 1 {name=l1458_5 lab=VSS}
N 2522 27395 2542 27395 {lab=VSS}
C {./lab_pin.sym} 2542 27395 0 1 {name=l1458_6 lab=VSS}
C {./aoi21_1.sym} 2835 27375 0 0 {name=Xn_1400}
N 2743 27345 2723 27345 {lab=n_0794}
C {./lab_pin.sym} 2723 27345 0 0 {name=l1459_0 lab=n_0794}
N 2743 27365 2723 27365 {lab=n_0802}
C {./lab_pin.sym} 2723 27365 0 0 {name=l1459_1 lab=n_0802}
N 2743 27385 2723 27385 {lab=n_0804}
C {./lab_pin.sym} 2723 27385 0 0 {name=l1459_2 lab=n_0804}
N 2743 27405 2723 27405 {lab=n_0805}
C {./lab_pin.sym} 2723 27405 0 0 {name=l1459_3 lab=n_0805}
N 2927 27345 2947 27345 {lab=VDD}
C {./lab_pin.sym} 2947 27345 0 1 {name=l1459_4 lab=VDD}
N 2927 27365 2947 27365 {lab=VDD}
C {./lab_pin.sym} 2947 27365 0 1 {name=l1459_5 lab=VDD}
N 2927 27385 2947 27385 {lab=VSS}
C {./lab_pin.sym} 2947 27385 0 1 {name=l1459_6 lab=VSS}
N 2927 27405 2947 27405 {lab=VSS}
C {./lab_pin.sym} 2947 27405 0 1 {name=l1459_7 lab=VSS}
C {./nor2_1.sym} 3240 27375 0 0 {name=Xn_1401}
N 3148 27345 3128 27345 {lab=u_cas_int_out_int2_b10}
C {./lab_pin.sym} 3128 27345 0 0 {name=l1460_0 lab=u_cas_int_out_int2_b10}
N 3148 27365 3128 27365 {lab=u_cas_int_out_int1_b10}
C {./lab_pin.sym} 3128 27365 0 0 {name=l1460_1 lab=u_cas_int_out_int1_b10}
N 3148 27385 3128 27385 {lab=n_0806}
C {./lab_pin.sym} 3128 27385 0 0 {name=l1460_2 lab=n_0806}
N 3148 27405 3128 27405 {lab=VDD}
C {./lab_pin.sym} 3128 27405 0 0 {name=l1460_3 lab=VDD}
N 3332 27355 3352 27355 {lab=VDD}
C {./lab_pin.sym} 3352 27355 0 1 {name=l1460_4 lab=VDD}
N 3332 27375 3352 27375 {lab=VSS}
C {./lab_pin.sym} 3352 27375 0 1 {name=l1460_5 lab=VSS}
N 3332 27395 3352 27395 {lab=VSS}
C {./lab_pin.sym} 3352 27395 0 1 {name=l1460_6 lab=VSS}
C {./and2_1.sym} 3645 27375 0 0 {name=Xn_1402}
N 3553 27345 3533 27345 {lab=u_cas_int_out_int2_b10}
C {./lab_pin.sym} 3533 27345 0 0 {name=l1461_0 lab=u_cas_int_out_int2_b10}
N 3553 27365 3533 27365 {lab=u_cas_int_out_int1_b10}
C {./lab_pin.sym} 3533 27365 0 0 {name=l1461_1 lab=u_cas_int_out_int1_b10}
N 3553 27385 3533 27385 {lab=n_0807}
C {./lab_pin.sym} 3533 27385 0 0 {name=l1461_2 lab=n_0807}
N 3553 27405 3533 27405 {lab=VDD}
C {./lab_pin.sym} 3533 27405 0 0 {name=l1461_3 lab=VDD}
N 3737 27355 3757 27355 {lab=VDD}
C {./lab_pin.sym} 3757 27355 0 1 {name=l1461_4 lab=VDD}
N 3737 27375 3757 27375 {lab=VSS}
C {./lab_pin.sym} 3757 27375 0 1 {name=l1461_5 lab=VSS}
N 3737 27395 3757 27395 {lab=VSS}
C {./lab_pin.sym} 3757 27395 0 1 {name=l1461_6 lab=VSS}
C {./nand2_1.sym} 4050 27375 0 0 {name=Xn_1403}
N 3958 27345 3938 27345 {lab=u_cas_int_out_int2_b10}
C {./lab_pin.sym} 3938 27345 0 0 {name=l1462_0 lab=u_cas_int_out_int2_b10}
N 3958 27365 3938 27365 {lab=u_cas_int_out_int1_b10}
C {./lab_pin.sym} 3938 27365 0 0 {name=l1462_1 lab=u_cas_int_out_int1_b10}
N 3958 27385 3938 27385 {lab=n_0808}
C {./lab_pin.sym} 3938 27385 0 0 {name=l1462_2 lab=n_0808}
N 3958 27405 3938 27405 {lab=VDD}
C {./lab_pin.sym} 3938 27405 0 0 {name=l1462_3 lab=VDD}
N 4142 27355 4162 27355 {lab=VDD}
C {./lab_pin.sym} 4162 27355 0 1 {name=l1462_4 lab=VDD}
N 4142 27375 4162 27375 {lab=VSS}
C {./lab_pin.sym} 4162 27375 0 1 {name=l1462_5 lab=VSS}
N 4142 27395 4162 27395 {lab=VSS}
C {./lab_pin.sym} 4162 27395 0 1 {name=l1462_6 lab=VSS}
C {./xnor3_1.sym} 4455 27375 0 0 {name=Xn_1404}
N 4363 27345 4343 27345 {lab=u_cas_int_out_int2_b10}
C {./lab_pin.sym} 4343 27345 0 0 {name=l1463_0 lab=u_cas_int_out_int2_b10}
N 4363 27365 4343 27365 {lab=u_cas_int_out_int1_b10}
C {./lab_pin.sym} 4343 27365 0 0 {name=l1463_1 lab=u_cas_int_out_int1_b10}
N 4363 27385 4343 27385 {lab=n_0805}
C {./lab_pin.sym} 4343 27385 0 0 {name=l1463_2 lab=n_0805}
N 4363 27405 4343 27405 {lab=n_0088}
C {./lab_pin.sym} 4343 27405 0 0 {name=l1463_3 lab=n_0088}
N 4547 27345 4567 27345 {lab=VDD}
C {./lab_pin.sym} 4567 27345 0 1 {name=l1463_4 lab=VDD}
N 4547 27365 4567 27365 {lab=VDD}
C {./lab_pin.sym} 4567 27365 0 1 {name=l1463_5 lab=VDD}
N 4547 27385 4567 27385 {lab=VSS}
C {./lab_pin.sym} 4567 27385 0 1 {name=l1463_6 lab=VSS}
N 4547 27405 4567 27405 {lab=VSS}
C {./lab_pin.sym} 4567 27405 0 1 {name=l1463_7 lab=VSS}
C {./oai21_1.sym} 0 27600 0 0 {name=Xn_1405}
N -92 27570 -112 27570 {lab=n_0805}
C {./lab_pin.sym} -112 27570 0 0 {name=l1464_0 lab=n_0805}
N -92 27590 -112 27590 {lab=n_0806}
C {./lab_pin.sym} -112 27590 0 0 {name=l1464_1 lab=n_0806}
N -92 27610 -112 27610 {lab=n_0808}
C {./lab_pin.sym} -112 27610 0 0 {name=l1464_2 lab=n_0808}
N -92 27630 -112 27630 {lab=n_0809}
C {./lab_pin.sym} -112 27630 0 0 {name=l1464_3 lab=n_0809}
N 92 27570 112 27570 {lab=VDD}
C {./lab_pin.sym} 112 27570 0 1 {name=l1464_4 lab=VDD}
N 92 27590 112 27590 {lab=VDD}
C {./lab_pin.sym} 112 27590 0 1 {name=l1464_5 lab=VDD}
N 92 27610 112 27610 {lab=VSS}
C {./lab_pin.sym} 112 27610 0 1 {name=l1464_6 lab=VSS}
N 92 27630 112 27630 {lab=VSS}
C {./lab_pin.sym} 112 27630 0 1 {name=l1464_7 lab=VSS}
C {./nand2_1.sym} 405 27600 0 0 {name=Xn_1406}
N 313 27570 293 27570 {lab=u_cas_int_out_int2_b11}
C {./lab_pin.sym} 293 27570 0 0 {name=l1465_0 lab=u_cas_int_out_int2_b11}
N 313 27590 293 27590 {lab=u_cas_int_out_int1_b11}
C {./lab_pin.sym} 293 27590 0 0 {name=l1465_1 lab=u_cas_int_out_int1_b11}
N 313 27610 293 27610 {lab=n_0810}
C {./lab_pin.sym} 293 27610 0 0 {name=l1465_2 lab=n_0810}
N 313 27630 293 27630 {lab=VDD}
C {./lab_pin.sym} 293 27630 0 0 {name=l1465_3 lab=VDD}
N 497 27580 517 27580 {lab=VDD}
C {./lab_pin.sym} 517 27580 0 1 {name=l1465_4 lab=VDD}
N 497 27600 517 27600 {lab=VSS}
C {./lab_pin.sym} 517 27600 0 1 {name=l1465_5 lab=VSS}
N 497 27620 517 27620 {lab=VSS}
C {./lab_pin.sym} 517 27620 0 1 {name=l1465_6 lab=VSS}
C {./xor3_1.sym} 810 27600 0 0 {name=Xn_1407}
N 718 27570 698 27570 {lab=u_cas_int_out_int2_b11}
C {./lab_pin.sym} 698 27570 0 0 {name=l1466_0 lab=u_cas_int_out_int2_b11}
N 718 27590 698 27590 {lab=u_cas_int_out_int1_b11}
C {./lab_pin.sym} 698 27590 0 0 {name=l1466_1 lab=u_cas_int_out_int1_b11}
N 718 27610 698 27610 {lab=n_0809}
C {./lab_pin.sym} 698 27610 0 0 {name=l1466_2 lab=n_0809}
N 718 27630 698 27630 {lab=n_0089}
C {./lab_pin.sym} 698 27630 0 0 {name=l1466_3 lab=n_0089}
N 902 27570 922 27570 {lab=VDD}
C {./lab_pin.sym} 922 27570 0 1 {name=l1466_4 lab=VDD}
N 902 27590 922 27590 {lab=VDD}
C {./lab_pin.sym} 922 27590 0 1 {name=l1466_5 lab=VDD}
N 902 27610 922 27610 {lab=VSS}
C {./lab_pin.sym} 922 27610 0 1 {name=l1466_6 lab=VSS}
N 902 27630 922 27630 {lab=VSS}
C {./lab_pin.sym} 922 27630 0 1 {name=l1466_7 lab=VSS}
C {./oai22_1.sym} 1215 27600 0 0 {name=Xn_1408}
N 1123 27560 1103 27560 {lab=u_cas_int_out_int2_b10}
C {./lab_pin.sym} 1103 27560 0 0 {name=l1467_0 lab=u_cas_int_out_int2_b10}
N 1123 27580 1103 27580 {lab=u_cas_int_out_int1_b10}
C {./lab_pin.sym} 1103 27580 0 0 {name=l1467_1 lab=u_cas_int_out_int1_b10}
N 1123 27600 1103 27600 {lab=u_cas_int_out_int1_b11}
C {./lab_pin.sym} 1103 27600 0 0 {name=l1467_2 lab=u_cas_int_out_int1_b11}
N 1123 27620 1103 27620 {lab=u_cas_int_out_int2_b11}
C {./lab_pin.sym} 1103 27620 0 0 {name=l1467_3 lab=u_cas_int_out_int2_b11}
N 1123 27640 1103 27640 {lab=n_0811}
C {./lab_pin.sym} 1103 27640 0 0 {name=l1467_4 lab=n_0811}
N 1307 27570 1327 27570 {lab=VDD}
C {./lab_pin.sym} 1327 27570 0 1 {name=l1467_5 lab=VDD}
N 1307 27590 1327 27590 {lab=VDD}
C {./lab_pin.sym} 1327 27590 0 1 {name=l1467_6 lab=VDD}
N 1307 27610 1327 27610 {lab=VSS}
C {./lab_pin.sym} 1327 27610 0 1 {name=l1467_7 lab=VSS}
N 1307 27630 1327 27630 {lab=VSS}
C {./lab_pin.sym} 1327 27630 0 1 {name=l1467_8 lab=VSS}
C {./nor2_1.sym} 1620 27600 0 0 {name=Xn_1409}
N 1528 27570 1508 27570 {lab=n_0811}
C {./lab_pin.sym} 1508 27570 0 0 {name=l1468_0 lab=n_0811}
N 1528 27590 1508 27590 {lab=n_0807}
C {./lab_pin.sym} 1508 27590 0 0 {name=l1468_1 lab=n_0807}
N 1528 27610 1508 27610 {lab=n_0812}
C {./lab_pin.sym} 1508 27610 0 0 {name=l1468_2 lab=n_0812}
N 1528 27630 1508 27630 {lab=VDD}
C {./lab_pin.sym} 1508 27630 0 0 {name=l1468_3 lab=VDD}
N 1712 27580 1732 27580 {lab=VDD}
C {./lab_pin.sym} 1732 27580 0 1 {name=l1468_4 lab=VDD}
N 1712 27600 1732 27600 {lab=VSS}
C {./lab_pin.sym} 1732 27600 0 1 {name=l1468_5 lab=VSS}
N 1712 27620 1732 27620 {lab=VSS}
C {./lab_pin.sym} 1732 27620 0 1 {name=l1468_6 lab=VSS}
C {./nand2_1.sym} 2025 27600 0 0 {name=Xn_1410}
N 1933 27570 1913 27570 {lab=n_0812}
C {./lab_pin.sym} 1913 27570 0 0 {name=l1469_0 lab=n_0812}
N 1933 27590 1913 27590 {lab=n_0810}
C {./lab_pin.sym} 1913 27590 0 0 {name=l1469_1 lab=n_0810}
N 1933 27610 1913 27610 {lab=n_0813}
C {./lab_pin.sym} 1913 27610 0 0 {name=l1469_2 lab=n_0813}
N 1933 27630 1913 27630 {lab=VDD}
C {./lab_pin.sym} 1913 27630 0 0 {name=l1469_3 lab=VDD}
N 2117 27580 2137 27580 {lab=VDD}
C {./lab_pin.sym} 2137 27580 0 1 {name=l1469_4 lab=VDD}
N 2117 27600 2137 27600 {lab=VSS}
C {./lab_pin.sym} 2137 27600 0 1 {name=l1469_5 lab=VSS}
N 2117 27620 2137 27620 {lab=VSS}
C {./lab_pin.sym} 2137 27620 0 1 {name=l1469_6 lab=VSS}
C {./nor2_1.sym} 2430 27600 0 0 {name=Xn_1411}
N 2338 27570 2318 27570 {lab=n_0801}
C {./lab_pin.sym} 2318 27570 0 0 {name=l1470_0 lab=n_0801}
N 2338 27590 2318 27590 {lab=n_0813}
C {./lab_pin.sym} 2318 27590 0 0 {name=l1470_1 lab=n_0813}
N 2338 27610 2318 27610 {lab=n_0814}
C {./lab_pin.sym} 2318 27610 0 0 {name=l1470_2 lab=n_0814}
N 2338 27630 2318 27630 {lab=VDD}
C {./lab_pin.sym} 2318 27630 0 0 {name=l1470_3 lab=VDD}
N 2522 27580 2542 27580 {lab=VDD}
C {./lab_pin.sym} 2542 27580 0 1 {name=l1470_4 lab=VDD}
N 2522 27600 2542 27600 {lab=VSS}
C {./lab_pin.sym} 2542 27600 0 1 {name=l1470_5 lab=VSS}
N 2522 27620 2542 27620 {lab=VSS}
C {./lab_pin.sym} 2542 27620 0 1 {name=l1470_6 lab=VSS}
C {./nand2_1.sym} 2835 27600 0 0 {name=Xn_1412}
N 2743 27570 2723 27570 {lab=n_0794}
C {./lab_pin.sym} 2723 27570 0 0 {name=l1471_0 lab=n_0794}
N 2743 27590 2723 27590 {lab=n_0814}
C {./lab_pin.sym} 2723 27590 0 0 {name=l1471_1 lab=n_0814}
N 2743 27610 2723 27610 {lab=n_0815}
C {./lab_pin.sym} 2723 27610 0 0 {name=l1471_2 lab=n_0815}
N 2743 27630 2723 27630 {lab=VDD}
C {./lab_pin.sym} 2723 27630 0 0 {name=l1471_3 lab=VDD}
N 2927 27580 2947 27580 {lab=VDD}
C {./lab_pin.sym} 2947 27580 0 1 {name=l1471_4 lab=VDD}
N 2927 27600 2947 27600 {lab=VSS}
C {./lab_pin.sym} 2947 27600 0 1 {name=l1471_5 lab=VSS}
N 2927 27620 2947 27620 {lab=VSS}
C {./lab_pin.sym} 2947 27620 0 1 {name=l1471_6 lab=VSS}
C {./oai211_1.sym} 3240 27600 0 0 {name=Xn_1413}
N 3148 27560 3128 27560 {lab=u_cas_int_out_int2_b11}
C {./lab_pin.sym} 3128 27560 0 0 {name=l1472_0 lab=u_cas_int_out_int2_b11}
N 3148 27580 3128 27580 {lab=u_cas_int_out_int1_b11}
C {./lab_pin.sym} 3128 27580 0 0 {name=l1472_1 lab=u_cas_int_out_int1_b11}
N 3148 27600 3128 27600 {lab=u_cas_int_out_int1_b10}
C {./lab_pin.sym} 3128 27600 0 0 {name=l1472_2 lab=u_cas_int_out_int1_b10}
N 3148 27620 3128 27620 {lab=u_cas_int_out_int2_b10}
C {./lab_pin.sym} 3128 27620 0 0 {name=l1472_3 lab=u_cas_int_out_int2_b10}
N 3148 27640 3128 27640 {lab=n_0816}
C {./lab_pin.sym} 3128 27640 0 0 {name=l1472_4 lab=n_0816}
N 3332 27570 3352 27570 {lab=VDD}
C {./lab_pin.sym} 3352 27570 0 1 {name=l1472_5 lab=VDD}
N 3332 27590 3352 27590 {lab=VDD}
C {./lab_pin.sym} 3352 27590 0 1 {name=l1472_6 lab=VDD}
N 3332 27610 3352 27610 {lab=VSS}
C {./lab_pin.sym} 3352 27610 0 1 {name=l1472_7 lab=VSS}
N 3332 27630 3352 27630 {lab=VSS}
C {./lab_pin.sym} 3352 27630 0 1 {name=l1472_8 lab=VSS}
C {./nand2_1.sym} 3645 27600 0 0 {name=Xn_1414}
N 3553 27570 3533 27570 {lab=n_0810}
C {./lab_pin.sym} 3533 27570 0 0 {name=l1473_0 lab=n_0810}
N 3553 27590 3533 27590 {lab=n_0816}
C {./lab_pin.sym} 3533 27590 0 0 {name=l1473_1 lab=n_0816}
N 3553 27610 3533 27610 {lab=n_0817}
C {./lab_pin.sym} 3533 27610 0 0 {name=l1473_2 lab=n_0817}
N 3553 27630 3533 27630 {lab=VDD}
C {./lab_pin.sym} 3533 27630 0 0 {name=l1473_3 lab=VDD}
N 3737 27580 3757 27580 {lab=VDD}
C {./lab_pin.sym} 3757 27580 0 1 {name=l1473_4 lab=VDD}
N 3737 27600 3757 27600 {lab=VSS}
C {./lab_pin.sym} 3757 27600 0 1 {name=l1473_5 lab=VSS}
N 3737 27620 3757 27620 {lab=VSS}
C {./lab_pin.sym} 3757 27620 0 1 {name=l1473_6 lab=VSS}
C {./aoi21_1.sym} 4050 27600 0 0 {name=Xn_1415}
N 3958 27570 3938 27570 {lab=n_0804}
C {./lab_pin.sym} 3938 27570 0 0 {name=l1474_0 lab=n_0804}
N 3958 27590 3938 27590 {lab=n_0812}
C {./lab_pin.sym} 3938 27590 0 0 {name=l1474_1 lab=n_0812}
N 3958 27610 3938 27610 {lab=n_0817}
C {./lab_pin.sym} 3938 27610 0 0 {name=l1474_2 lab=n_0817}
N 3958 27630 3938 27630 {lab=n_0818}
C {./lab_pin.sym} 3938 27630 0 0 {name=l1474_3 lab=n_0818}
N 4142 27570 4162 27570 {lab=VDD}
C {./lab_pin.sym} 4162 27570 0 1 {name=l1474_4 lab=VDD}
N 4142 27590 4162 27590 {lab=VDD}
C {./lab_pin.sym} 4162 27590 0 1 {name=l1474_5 lab=VDD}
N 4142 27610 4162 27610 {lab=VSS}
C {./lab_pin.sym} 4162 27610 0 1 {name=l1474_6 lab=VSS}
N 4142 27630 4162 27630 {lab=VSS}
C {./lab_pin.sym} 4162 27630 0 1 {name=l1474_7 lab=VSS}
C {./nand2_1.sym} 4455 27600 0 0 {name=Xn_1416}
N 4363 27570 4343 27570 {lab=n_0815}
C {./lab_pin.sym} 4343 27570 0 0 {name=l1475_0 lab=n_0815}
N 4363 27590 4343 27590 {lab=n_0818}
C {./lab_pin.sym} 4343 27590 0 0 {name=l1475_1 lab=n_0818}
N 4363 27610 4343 27610 {lab=n_0819}
C {./lab_pin.sym} 4343 27610 0 0 {name=l1475_2 lab=n_0819}
N 4363 27630 4343 27630 {lab=VDD}
C {./lab_pin.sym} 4343 27630 0 0 {name=l1475_3 lab=VDD}
N 4547 27580 4567 27580 {lab=VDD}
C {./lab_pin.sym} 4567 27580 0 1 {name=l1475_4 lab=VDD}
N 4547 27600 4567 27600 {lab=VSS}
C {./lab_pin.sym} 4567 27600 0 1 {name=l1475_5 lab=VSS}
N 4547 27620 4567 27620 {lab=VSS}
C {./lab_pin.sym} 4567 27620 0 1 {name=l1475_6 lab=VSS}
C {./nand2_1.sym} 0 27825 0 0 {name=Xn_1417}
N -92 27795 -112 27795 {lab=u_cas_int_out_int2_b12}
C {./lab_pin.sym} -112 27795 0 0 {name=l1476_0 lab=u_cas_int_out_int2_b12}
N -92 27815 -112 27815 {lab=u_cas_int_out_int1_b12}
C {./lab_pin.sym} -112 27815 0 0 {name=l1476_1 lab=u_cas_int_out_int1_b12}
N -92 27835 -112 27835 {lab=n_0820}
C {./lab_pin.sym} -112 27835 0 0 {name=l1476_2 lab=n_0820}
N -92 27855 -112 27855 {lab=VDD}
C {./lab_pin.sym} -112 27855 0 0 {name=l1476_3 lab=VDD}
N 92 27805 112 27805 {lab=VDD}
C {./lab_pin.sym} 112 27805 0 1 {name=l1476_4 lab=VDD}
N 92 27825 112 27825 {lab=VSS}
C {./lab_pin.sym} 112 27825 0 1 {name=l1476_5 lab=VSS}
N 92 27845 112 27845 {lab=VSS}
C {./lab_pin.sym} 112 27845 0 1 {name=l1476_6 lab=VSS}
C {./or2_1.sym} 405 27825 0 0 {name=Xn_1418}
N 313 27795 293 27795 {lab=u_cas_int_out_int2_b12}
C {./lab_pin.sym} 293 27795 0 0 {name=l1477_0 lab=u_cas_int_out_int2_b12}
N 313 27815 293 27815 {lab=u_cas_int_out_int1_b12}
C {./lab_pin.sym} 293 27815 0 0 {name=l1477_1 lab=u_cas_int_out_int1_b12}
N 313 27835 293 27835 {lab=n_0821}
C {./lab_pin.sym} 293 27835 0 0 {name=l1477_2 lab=n_0821}
N 313 27855 293 27855 {lab=VDD}
C {./lab_pin.sym} 293 27855 0 0 {name=l1477_3 lab=VDD}
N 497 27805 517 27805 {lab=VDD}
C {./lab_pin.sym} 517 27805 0 1 {name=l1477_4 lab=VDD}
N 497 27825 517 27825 {lab=VSS}
C {./lab_pin.sym} 517 27825 0 1 {name=l1477_5 lab=VSS}
N 497 27845 517 27845 {lab=VSS}
C {./lab_pin.sym} 517 27845 0 1 {name=l1477_6 lab=VSS}
C {./nand2_1.sym} 810 27825 0 0 {name=Xn_1419}
N 718 27795 698 27795 {lab=n_0820}
C {./lab_pin.sym} 698 27795 0 0 {name=l1478_0 lab=n_0820}
N 718 27815 698 27815 {lab=n_0821}
C {./lab_pin.sym} 698 27815 0 0 {name=l1478_1 lab=n_0821}
N 718 27835 698 27835 {lab=n_0822}
C {./lab_pin.sym} 698 27835 0 0 {name=l1478_2 lab=n_0822}
N 718 27855 698 27855 {lab=VDD}
C {./lab_pin.sym} 698 27855 0 0 {name=l1478_3 lab=VDD}
N 902 27805 922 27805 {lab=VDD}
C {./lab_pin.sym} 922 27805 0 1 {name=l1478_4 lab=VDD}
N 902 27825 922 27825 {lab=VSS}
C {./lab_pin.sym} 922 27825 0 1 {name=l1478_5 lab=VSS}
N 902 27845 922 27845 {lab=VSS}
C {./lab_pin.sym} 922 27845 0 1 {name=l1478_6 lab=VSS}
C {./aoi21_1.sym} 1215 27825 0 0 {name=Xn_1420}
N 1123 27795 1103 27795 {lab=n_0815}
C {./lab_pin.sym} 1103 27795 0 0 {name=l1479_0 lab=n_0815}
N 1123 27815 1103 27815 {lab=n_0818}
C {./lab_pin.sym} 1103 27815 0 0 {name=l1479_1 lab=n_0818}
N 1123 27835 1103 27835 {lab=n_0822}
C {./lab_pin.sym} 1103 27835 0 0 {name=l1479_2 lab=n_0822}
N 1123 27855 1103 27855 {lab=n_0823}
C {./lab_pin.sym} 1103 27855 0 0 {name=l1479_3 lab=n_0823}
N 1307 27795 1327 27795 {lab=VDD}
C {./lab_pin.sym} 1327 27795 0 1 {name=l1479_4 lab=VDD}
N 1307 27815 1327 27815 {lab=VDD}
C {./lab_pin.sym} 1327 27815 0 1 {name=l1479_5 lab=VDD}
N 1307 27835 1327 27835 {lab=VSS}
C {./lab_pin.sym} 1327 27835 0 1 {name=l1479_6 lab=VSS}
N 1307 27855 1327 27855 {lab=VSS}
C {./lab_pin.sym} 1327 27855 0 1 {name=l1479_7 lab=VSS}
C {./xnor2_1.sym} 1620 27825 0 0 {name=Xn_1421}
N 1528 27795 1508 27795 {lab=n_0819}
C {./lab_pin.sym} 1508 27795 0 0 {name=l1480_0 lab=n_0819}
N 1528 27815 1508 27815 {lab=n_0822}
C {./lab_pin.sym} 1508 27815 0 0 {name=l1480_1 lab=n_0822}
N 1528 27835 1508 27835 {lab=n_0090}
C {./lab_pin.sym} 1508 27835 0 0 {name=l1480_2 lab=n_0090}
N 1528 27855 1508 27855 {lab=VDD}
C {./lab_pin.sym} 1508 27855 0 0 {name=l1480_3 lab=VDD}
N 1712 27805 1732 27805 {lab=VDD}
C {./lab_pin.sym} 1732 27805 0 1 {name=l1480_4 lab=VDD}
N 1712 27825 1732 27825 {lab=VSS}
C {./lab_pin.sym} 1732 27825 0 1 {name=l1480_5 lab=VSS}
N 1712 27845 1732 27845 {lab=VSS}
C {./lab_pin.sym} 1732 27845 0 1 {name=l1480_6 lab=VSS}
C {./or2_1.sym} 2025 27825 0 0 {name=Xn_1422}
N 1933 27795 1913 27795 {lab=u_cas_int_out_int2_b13}
C {./lab_pin.sym} 1913 27795 0 0 {name=l1481_0 lab=u_cas_int_out_int2_b13}
N 1933 27815 1913 27815 {lab=u_cas_int_out_int1_b13}
C {./lab_pin.sym} 1913 27815 0 0 {name=l1481_1 lab=u_cas_int_out_int1_b13}
N 1933 27835 1913 27835 {lab=n_0824}
C {./lab_pin.sym} 1913 27835 0 0 {name=l1481_2 lab=n_0824}
N 1933 27855 1913 27855 {lab=VDD}
C {./lab_pin.sym} 1913 27855 0 0 {name=l1481_3 lab=VDD}
N 2117 27805 2137 27805 {lab=VDD}
C {./lab_pin.sym} 2137 27805 0 1 {name=l1481_4 lab=VDD}
N 2117 27825 2137 27825 {lab=VSS}
C {./lab_pin.sym} 2137 27825 0 1 {name=l1481_5 lab=VSS}
N 2117 27845 2137 27845 {lab=VSS}
C {./lab_pin.sym} 2137 27845 0 1 {name=l1481_6 lab=VSS}
C {./nand2_1.sym} 2430 27825 0 0 {name=Xn_1423}
N 2338 27795 2318 27795 {lab=u_cas_int_out_int2_b13}
C {./lab_pin.sym} 2318 27795 0 0 {name=l1482_0 lab=u_cas_int_out_int2_b13}
N 2338 27815 2318 27815 {lab=u_cas_int_out_int1_b13}
C {./lab_pin.sym} 2318 27815 0 0 {name=l1482_1 lab=u_cas_int_out_int1_b13}
N 2338 27835 2318 27835 {lab=n_0825}
C {./lab_pin.sym} 2318 27835 0 0 {name=l1482_2 lab=n_0825}
N 2338 27855 2318 27855 {lab=VDD}
C {./lab_pin.sym} 2318 27855 0 0 {name=l1482_3 lab=VDD}
N 2522 27805 2542 27805 {lab=VDD}
C {./lab_pin.sym} 2542 27805 0 1 {name=l1482_4 lab=VDD}
N 2522 27825 2542 27825 {lab=VSS}
C {./lab_pin.sym} 2542 27825 0 1 {name=l1482_5 lab=VSS}
N 2522 27845 2542 27845 {lab=VSS}
C {./lab_pin.sym} 2542 27845 0 1 {name=l1482_6 lab=VSS}
C {./aoi21_1.sym} 2835 27825 0 0 {name=Xn_1424}
N 2743 27795 2723 27795 {lab=u_cas_int_out_int2_b12}
C {./lab_pin.sym} 2723 27795 0 0 {name=l1483_0 lab=u_cas_int_out_int2_b12}
N 2743 27815 2723 27815 {lab=u_cas_int_out_int1_b12}
C {./lab_pin.sym} 2723 27815 0 0 {name=l1483_1 lab=u_cas_int_out_int1_b12}
N 2743 27835 2723 27835 {lab=n_0823}
C {./lab_pin.sym} 2723 27835 0 0 {name=l1483_2 lab=n_0823}
N 2743 27855 2723 27855 {lab=n_0826}
C {./lab_pin.sym} 2723 27855 0 0 {name=l1483_3 lab=n_0826}
N 2927 27795 2947 27795 {lab=VDD}
C {./lab_pin.sym} 2947 27795 0 1 {name=l1483_4 lab=VDD}
N 2927 27815 2947 27815 {lab=VDD}
C {./lab_pin.sym} 2947 27815 0 1 {name=l1483_5 lab=VDD}
N 2927 27835 2947 27835 {lab=VSS}
C {./lab_pin.sym} 2947 27835 0 1 {name=l1483_6 lab=VSS}
N 2927 27855 2947 27855 {lab=VSS}
C {./lab_pin.sym} 2947 27855 0 1 {name=l1483_7 lab=VSS}
C {./xnor3_1.sym} 3240 27825 0 0 {name=Xn_1425}
N 3148 27795 3128 27795 {lab=u_cas_int_out_int2_b13}
C {./lab_pin.sym} 3128 27795 0 0 {name=l1484_0 lab=u_cas_int_out_int2_b13}
N 3148 27815 3128 27815 {lab=u_cas_int_out_int1_b13}
C {./lab_pin.sym} 3128 27815 0 0 {name=l1484_1 lab=u_cas_int_out_int1_b13}
N 3148 27835 3128 27835 {lab=n_0826}
C {./lab_pin.sym} 3128 27835 0 0 {name=l1484_2 lab=n_0826}
N 3148 27855 3128 27855 {lab=n_0091}
C {./lab_pin.sym} 3128 27855 0 0 {name=l1484_3 lab=n_0091}
N 3332 27795 3352 27795 {lab=VDD}
C {./lab_pin.sym} 3352 27795 0 1 {name=l1484_4 lab=VDD}
N 3332 27815 3352 27815 {lab=VDD}
C {./lab_pin.sym} 3352 27815 0 1 {name=l1484_5 lab=VDD}
N 3332 27835 3352 27835 {lab=VSS}
C {./lab_pin.sym} 3352 27835 0 1 {name=l1484_6 lab=VSS}
N 3332 27855 3352 27855 {lab=VSS}
C {./lab_pin.sym} 3352 27855 0 1 {name=l1484_7 lab=VSS}
C {./nand2_1.sym} 3645 27825 0 0 {name=Xn_1426}
N 3553 27795 3533 27795 {lab=u_cas_int_out_int2_b14}
C {./lab_pin.sym} 3533 27795 0 0 {name=l1485_0 lab=u_cas_int_out_int2_b14}
N 3553 27815 3533 27815 {lab=u_cas_int_out_int1_b14}
C {./lab_pin.sym} 3533 27815 0 0 {name=l1485_1 lab=u_cas_int_out_int1_b14}
N 3553 27835 3533 27835 {lab=n_0827}
C {./lab_pin.sym} 3533 27835 0 0 {name=l1485_2 lab=n_0827}
N 3553 27855 3533 27855 {lab=VDD}
C {./lab_pin.sym} 3533 27855 0 0 {name=l1485_3 lab=VDD}
N 3737 27805 3757 27805 {lab=VDD}
C {./lab_pin.sym} 3757 27805 0 1 {name=l1485_4 lab=VDD}
N 3737 27825 3757 27825 {lab=VSS}
C {./lab_pin.sym} 3757 27825 0 1 {name=l1485_5 lab=VSS}
N 3737 27845 3757 27845 {lab=VSS}
C {./lab_pin.sym} 3757 27845 0 1 {name=l1485_6 lab=VSS}
C {./xor2_1.sym} 4050 27825 0 0 {name=Xn_1427}
N 3958 27795 3938 27795 {lab=u_cas_int_out_int2_b14}
C {./lab_pin.sym} 3938 27795 0 0 {name=l1486_0 lab=u_cas_int_out_int2_b14}
N 3958 27815 3938 27815 {lab=u_cas_int_out_int1_b14}
C {./lab_pin.sym} 3938 27815 0 0 {name=l1486_1 lab=u_cas_int_out_int1_b14}
N 3958 27835 3938 27835 {lab=n_0828}
C {./lab_pin.sym} 3938 27835 0 0 {name=l1486_2 lab=n_0828}
N 3958 27855 3938 27855 {lab=VDD}
C {./lab_pin.sym} 3938 27855 0 0 {name=l1486_3 lab=VDD}
N 4142 27805 4162 27805 {lab=VDD}
C {./lab_pin.sym} 4162 27805 0 1 {name=l1486_4 lab=VDD}
N 4142 27825 4162 27825 {lab=VSS}
C {./lab_pin.sym} 4162 27825 0 1 {name=l1486_5 lab=VSS}
N 4142 27845 4162 27845 {lab=VSS}
C {./lab_pin.sym} 4162 27845 0 1 {name=l1486_6 lab=VSS}
C {./nand2_1.sym} 4455 27825 0 0 {name=Xn_1428}
N 4363 27795 4343 27795 {lab=n_0820}
C {./lab_pin.sym} 4343 27795 0 0 {name=l1487_0 lab=n_0820}
N 4363 27815 4343 27815 {lab=n_0825}
C {./lab_pin.sym} 4343 27815 0 0 {name=l1487_1 lab=n_0825}
N 4363 27835 4343 27835 {lab=n_0829}
C {./lab_pin.sym} 4343 27835 0 0 {name=l1487_2 lab=n_0829}
N 4363 27855 4343 27855 {lab=VDD}
C {./lab_pin.sym} 4343 27855 0 0 {name=l1487_3 lab=VDD}
N 4547 27805 4567 27805 {lab=VDD}
C {./lab_pin.sym} 4567 27805 0 1 {name=l1487_4 lab=VDD}
N 4547 27825 4567 27825 {lab=VSS}
C {./lab_pin.sym} 4567 27825 0 1 {name=l1487_5 lab=VSS}
N 4547 27845 4567 27845 {lab=VSS}
C {./lab_pin.sym} 4567 27845 0 1 {name=l1487_6 lab=VSS}
C {./nand2_1.sym} 0 28050 0 0 {name=Xn_1429}
N -92 28020 -112 28020 {lab=n_0824}
C {./lab_pin.sym} -112 28020 0 0 {name=l1488_0 lab=n_0824}
N -92 28040 -112 28040 {lab=n_0829}
C {./lab_pin.sym} -112 28040 0 0 {name=l1488_1 lab=n_0829}
N -92 28060 -112 28060 {lab=n_0830}
C {./lab_pin.sym} -112 28060 0 0 {name=l1488_2 lab=n_0830}
N -92 28080 -112 28080 {lab=VDD}
C {./lab_pin.sym} -112 28080 0 0 {name=l1488_3 lab=VDD}
N 92 28030 112 28030 {lab=VDD}
C {./lab_pin.sym} 112 28030 0 1 {name=l1488_4 lab=VDD}
N 92 28050 112 28050 {lab=VSS}
C {./lab_pin.sym} 112 28050 0 1 {name=l1488_5 lab=VSS}
N 92 28070 112 28070 {lab=VSS}
C {./lab_pin.sym} 112 28070 0 1 {name=l1488_6 lab=VSS}
C {./oai22_1.sym} 405 28050 0 0 {name=Xn_1430}
N 313 28010 293 28010 {lab=n_0823}
C {./lab_pin.sym} 293 28010 0 0 {name=l1489_0 lab=n_0823}
N 313 28030 293 28030 {lab=n_0829}
C {./lab_pin.sym} 293 28030 0 0 {name=l1489_1 lab=n_0829}
N 313 28050 293 28050 {lab=u_cas_int_out_int2_b13}
C {./lab_pin.sym} 293 28050 0 0 {name=l1489_2 lab=u_cas_int_out_int2_b13}
N 313 28070 293 28070 {lab=u_cas_int_out_int1_b13}
C {./lab_pin.sym} 293 28070 0 0 {name=l1489_3 lab=u_cas_int_out_int1_b13}
N 313 28090 293 28090 {lab=n_0831}
C {./lab_pin.sym} 293 28090 0 0 {name=l1489_4 lab=n_0831}
N 497 28020 517 28020 {lab=VDD}
C {./lab_pin.sym} 517 28020 0 1 {name=l1489_5 lab=VDD}
N 497 28040 517 28040 {lab=VDD}
C {./lab_pin.sym} 517 28040 0 1 {name=l1489_6 lab=VDD}
N 497 28060 517 28060 {lab=VSS}
C {./lab_pin.sym} 517 28060 0 1 {name=l1489_7 lab=VSS}
N 497 28080 517 28080 {lab=VSS}
C {./lab_pin.sym} 517 28080 0 1 {name=l1489_8 lab=VSS}
C {./oai211_1.sym} 810 28050 0 0 {name=Xn_1431}
N 718 28010 698 28010 {lab=n_0823}
C {./lab_pin.sym} 698 28010 0 0 {name=l1490_0 lab=n_0823}
N 718 28030 698 28030 {lab=n_0829}
C {./lab_pin.sym} 698 28030 0 0 {name=l1490_1 lab=n_0829}
N 718 28050 698 28050 {lab=n_0828}
C {./lab_pin.sym} 698 28050 0 0 {name=l1490_2 lab=n_0828}
N 718 28070 698 28070 {lab=n_0824}
C {./lab_pin.sym} 698 28070 0 0 {name=l1490_3 lab=n_0824}
N 718 28090 698 28090 {lab=n_0832}
C {./lab_pin.sym} 698 28090 0 0 {name=l1490_4 lab=n_0832}
N 902 28020 922 28020 {lab=VDD}
C {./lab_pin.sym} 922 28020 0 1 {name=l1490_5 lab=VDD}
N 902 28040 922 28040 {lab=VDD}
C {./lab_pin.sym} 922 28040 0 1 {name=l1490_6 lab=VDD}
N 902 28060 922 28060 {lab=VSS}
C {./lab_pin.sym} 922 28060 0 1 {name=l1490_7 lab=VSS}
N 902 28080 922 28080 {lab=VSS}
C {./lab_pin.sym} 922 28080 0 1 {name=l1490_8 lab=VSS}
C {./xnor2_1.sym} 1215 28050 0 0 {name=Xn_1432}
N 1123 28020 1103 28020 {lab=n_0828}
C {./lab_pin.sym} 1103 28020 0 0 {name=l1491_0 lab=n_0828}
N 1123 28040 1103 28040 {lab=n_0831}
C {./lab_pin.sym} 1103 28040 0 0 {name=l1491_1 lab=n_0831}
N 1123 28060 1103 28060 {lab=n_0092}
C {./lab_pin.sym} 1103 28060 0 0 {name=l1491_2 lab=n_0092}
N 1123 28080 1103 28080 {lab=VDD}
C {./lab_pin.sym} 1103 28080 0 0 {name=l1491_3 lab=VDD}
N 1307 28030 1327 28030 {lab=VDD}
C {./lab_pin.sym} 1327 28030 0 1 {name=l1491_4 lab=VDD}
N 1307 28050 1327 28050 {lab=VSS}
C {./lab_pin.sym} 1327 28050 0 1 {name=l1491_5 lab=VSS}
N 1307 28070 1327 28070 {lab=VSS}
C {./lab_pin.sym} 1327 28070 0 1 {name=l1491_6 lab=VSS}
C {./nor2_1.sym} 1620 28050 0 0 {name=Xn_1433}
N 1528 28020 1508 28020 {lab=u_cas_int_out_int2_b15}
C {./lab_pin.sym} 1508 28020 0 0 {name=l1492_0 lab=u_cas_int_out_int2_b15}
N 1528 28040 1508 28040 {lab=u_cas_int_out_int1_b15}
C {./lab_pin.sym} 1508 28040 0 0 {name=l1492_1 lab=u_cas_int_out_int1_b15}
N 1528 28060 1508 28060 {lab=n_0833}
C {./lab_pin.sym} 1508 28060 0 0 {name=l1492_2 lab=n_0833}
N 1528 28080 1508 28080 {lab=VDD}
C {./lab_pin.sym} 1508 28080 0 0 {name=l1492_3 lab=VDD}
N 1712 28030 1732 28030 {lab=VDD}
C {./lab_pin.sym} 1732 28030 0 1 {name=l1492_4 lab=VDD}
N 1712 28050 1732 28050 {lab=VSS}
C {./lab_pin.sym} 1732 28050 0 1 {name=l1492_5 lab=VSS}
N 1712 28070 1732 28070 {lab=VSS}
C {./lab_pin.sym} 1732 28070 0 1 {name=l1492_6 lab=VSS}
C {./nand2_1.sym} 2025 28050 0 0 {name=Xn_1434}
N 1933 28020 1913 28020 {lab=u_cas_int_out_int2_b15}
C {./lab_pin.sym} 1913 28020 0 0 {name=l1493_0 lab=u_cas_int_out_int2_b15}
N 1933 28040 1913 28040 {lab=u_cas_int_out_int1_b15}
C {./lab_pin.sym} 1913 28040 0 0 {name=l1493_1 lab=u_cas_int_out_int1_b15}
N 1933 28060 1913 28060 {lab=n_0834}
C {./lab_pin.sym} 1913 28060 0 0 {name=l1493_2 lab=n_0834}
N 1933 28080 1913 28080 {lab=VDD}
C {./lab_pin.sym} 1913 28080 0 0 {name=l1493_3 lab=VDD}
N 2117 28030 2137 28030 {lab=VDD}
C {./lab_pin.sym} 2137 28030 0 1 {name=l1493_4 lab=VDD}
N 2117 28050 2137 28050 {lab=VSS}
C {./lab_pin.sym} 2137 28050 0 1 {name=l1493_5 lab=VSS}
N 2117 28070 2137 28070 {lab=VSS}
C {./lab_pin.sym} 2137 28070 0 1 {name=l1493_6 lab=VSS}
C {./xor2_1.sym} 2430 28050 0 0 {name=Xn_1435}
N 2338 28020 2318 28020 {lab=u_cas_int_out_int2_b15}
C {./lab_pin.sym} 2318 28020 0 0 {name=l1494_0 lab=u_cas_int_out_int2_b15}
N 2338 28040 2318 28040 {lab=u_cas_int_out_int1_b15}
C {./lab_pin.sym} 2318 28040 0 0 {name=l1494_1 lab=u_cas_int_out_int1_b15}
N 2338 28060 2318 28060 {lab=n_0835}
C {./lab_pin.sym} 2318 28060 0 0 {name=l1494_2 lab=n_0835}
N 2338 28080 2318 28080 {lab=VDD}
C {./lab_pin.sym} 2318 28080 0 0 {name=l1494_3 lab=VDD}
N 2522 28030 2542 28030 {lab=VDD}
C {./lab_pin.sym} 2542 28030 0 1 {name=l1494_4 lab=VDD}
N 2522 28050 2542 28050 {lab=VSS}
C {./lab_pin.sym} 2542 28050 0 1 {name=l1494_5 lab=VSS}
N 2522 28070 2542 28070 {lab=VSS}
C {./lab_pin.sym} 2542 28070 0 1 {name=l1494_6 lab=VSS}
C {./nand2_1.sym} 2835 28050 0 0 {name=Xn_1436}
N 2743 28020 2723 28020 {lab=n_0827}
C {./lab_pin.sym} 2723 28020 0 0 {name=l1495_0 lab=n_0827}
N 2743 28040 2723 28040 {lab=n_0832}
C {./lab_pin.sym} 2723 28040 0 0 {name=l1495_1 lab=n_0832}
N 2743 28060 2723 28060 {lab=n_0836}
C {./lab_pin.sym} 2723 28060 0 0 {name=l1495_2 lab=n_0836}
N 2743 28080 2723 28080 {lab=VDD}
C {./lab_pin.sym} 2723 28080 0 0 {name=l1495_3 lab=VDD}
N 2927 28030 2947 28030 {lab=VDD}
C {./lab_pin.sym} 2947 28030 0 1 {name=l1495_4 lab=VDD}
N 2927 28050 2947 28050 {lab=VSS}
C {./lab_pin.sym} 2947 28050 0 1 {name=l1495_5 lab=VSS}
N 2927 28070 2947 28070 {lab=VSS}
C {./lab_pin.sym} 2947 28070 0 1 {name=l1495_6 lab=VSS}
C {./xor2_1.sym} 3240 28050 0 0 {name=Xn_1437}
N 3148 28020 3128 28020 {lab=n_0835}
C {./lab_pin.sym} 3128 28020 0 0 {name=l1496_0 lab=n_0835}
N 3148 28040 3128 28040 {lab=n_0836}
C {./lab_pin.sym} 3128 28040 0 0 {name=l1496_1 lab=n_0836}
N 3148 28060 3128 28060 {lab=n_0093}
C {./lab_pin.sym} 3128 28060 0 0 {name=l1496_2 lab=n_0093}
N 3148 28080 3128 28080 {lab=VDD}
C {./lab_pin.sym} 3128 28080 0 0 {name=l1496_3 lab=VDD}
N 3332 28030 3352 28030 {lab=VDD}
C {./lab_pin.sym} 3352 28030 0 1 {name=l1496_4 lab=VDD}
N 3332 28050 3352 28050 {lab=VSS}
C {./lab_pin.sym} 3352 28050 0 1 {name=l1496_5 lab=VSS}
N 3332 28070 3352 28070 {lab=VSS}
C {./lab_pin.sym} 3352 28070 0 1 {name=l1496_6 lab=VSS}
C {./nand2_1.sym} 3645 28050 0 0 {name=Xn_1438}
N 3553 28020 3533 28020 {lab=n_0828}
C {./lab_pin.sym} 3533 28020 0 0 {name=l1497_0 lab=n_0828}
N 3553 28040 3533 28040 {lab=n_0835}
C {./lab_pin.sym} 3533 28040 0 0 {name=l1497_1 lab=n_0835}
N 3553 28060 3533 28060 {lab=n_0837}
C {./lab_pin.sym} 3533 28060 0 0 {name=l1497_2 lab=n_0837}
N 3553 28080 3533 28080 {lab=VDD}
C {./lab_pin.sym} 3533 28080 0 0 {name=l1497_3 lab=VDD}
N 3737 28030 3757 28030 {lab=VDD}
C {./lab_pin.sym} 3757 28030 0 1 {name=l1497_4 lab=VDD}
N 3737 28050 3757 28050 {lab=VSS}
C {./lab_pin.sym} 3757 28050 0 1 {name=l1497_5 lab=VSS}
N 3737 28070 3757 28070 {lab=VSS}
C {./lab_pin.sym} 3757 28070 0 1 {name=l1497_6 lab=VSS}
C {./clkinv_1.sym} 4050 28050 0 0 {name=Xn_1439}
N 3958 28030 3938 28030 {lab=n_0837}
C {./lab_pin.sym} 3938 28030 0 0 {name=l1498_0 lab=n_0837}
N 3958 28050 3938 28050 {lab=n_0838}
C {./lab_pin.sym} 3938 28050 0 0 {name=l1498_1 lab=n_0838}
N 3958 28070 3938 28070 {lab=VDD}
C {./lab_pin.sym} 3938 28070 0 0 {name=l1498_2 lab=VDD}
N 4142 28030 4162 28030 {lab=VDD}
C {./lab_pin.sym} 4162 28030 0 1 {name=l1498_3 lab=VDD}
N 4142 28050 4162 28050 {lab=VSS}
C {./lab_pin.sym} 4162 28050 0 1 {name=l1498_4 lab=VSS}
N 4142 28070 4162 28070 {lab=VSS}
C {./lab_pin.sym} 4162 28070 0 1 {name=l1498_5 lab=VSS}
C {./nand4_1.sym} 4455 28050 0 0 {name=Xn_1440}
N 4363 28010 4343 28010 {lab=n_0820}
C {./lab_pin.sym} 4343 28010 0 0 {name=l1499_0 lab=n_0820}
N 4363 28030 4343 28030 {lab=n_0821}
C {./lab_pin.sym} 4343 28030 0 0 {name=l1499_1 lab=n_0821}
N 4363 28050 4343 28050 {lab=n_0824}
C {./lab_pin.sym} 4343 28050 0 0 {name=l1499_2 lab=n_0824}
N 4363 28070 4343 28070 {lab=n_0825}
C {./lab_pin.sym} 4343 28070 0 0 {name=l1499_3 lab=n_0825}
N 4363 28090 4343 28090 {lab=n_0839}
C {./lab_pin.sym} 4343 28090 0 0 {name=l1499_4 lab=n_0839}
N 4547 28020 4567 28020 {lab=VDD}
C {./lab_pin.sym} 4567 28020 0 1 {name=l1499_5 lab=VDD}
N 4547 28040 4567 28040 {lab=VDD}
C {./lab_pin.sym} 4567 28040 0 1 {name=l1499_6 lab=VDD}
N 4547 28060 4567 28060 {lab=VSS}
C {./lab_pin.sym} 4567 28060 0 1 {name=l1499_7 lab=VSS}
N 4547 28080 4567 28080 {lab=VSS}
C {./lab_pin.sym} 4567 28080 0 1 {name=l1499_8 lab=VSS}
C {./oai21_1.sym} 0 28275 0 0 {name=Xn_1441}
N -92 28245 -112 28245 {lab=n_0818}
C {./lab_pin.sym} -112 28245 0 0 {name=l1500_0 lab=n_0818}
N -92 28265 -112 28265 {lab=n_0839}
C {./lab_pin.sym} -112 28265 0 0 {name=l1500_1 lab=n_0839}
N -92 28285 -112 28285 {lab=n_0830}
C {./lab_pin.sym} -112 28285 0 0 {name=l1500_2 lab=n_0830}
N -92 28305 -112 28305 {lab=n_0840}
C {./lab_pin.sym} -112 28305 0 0 {name=l1500_3 lab=n_0840}
N 92 28245 112 28245 {lab=VDD}
C {./lab_pin.sym} 112 28245 0 1 {name=l1500_4 lab=VDD}
N 92 28265 112 28265 {lab=VDD}
C {./lab_pin.sym} 112 28265 0 1 {name=l1500_5 lab=VDD}
N 92 28285 112 28285 {lab=VSS}
C {./lab_pin.sym} 112 28285 0 1 {name=l1500_6 lab=VSS}
N 92 28305 112 28305 {lab=VSS}
C {./lab_pin.sym} 112 28305 0 1 {name=l1500_7 lab=VSS}
C {./oai21_1.sym} 405 28275 0 0 {name=Xn_1442}
N 313 28245 293 28245 {lab=n_0833}
C {./lab_pin.sym} 293 28245 0 0 {name=l1501_0 lab=n_0833}
N 313 28265 293 28265 {lab=n_0827}
C {./lab_pin.sym} 293 28265 0 0 {name=l1501_1 lab=n_0827}
N 313 28285 293 28285 {lab=n_0834}
C {./lab_pin.sym} 293 28285 0 0 {name=l1501_2 lab=n_0834}
N 313 28305 293 28305 {lab=n_0841}
C {./lab_pin.sym} 293 28305 0 0 {name=l1501_3 lab=n_0841}
N 497 28245 517 28245 {lab=VDD}
C {./lab_pin.sym} 517 28245 0 1 {name=l1501_4 lab=VDD}
N 497 28265 517 28265 {lab=VDD}
C {./lab_pin.sym} 517 28265 0 1 {name=l1501_5 lab=VDD}
N 497 28285 517 28285 {lab=VSS}
C {./lab_pin.sym} 517 28285 0 1 {name=l1501_6 lab=VSS}
N 497 28305 517 28305 {lab=VSS}
C {./lab_pin.sym} 517 28305 0 1 {name=l1501_7 lab=VSS}
C {./aoi21_1.sym} 810 28275 0 0 {name=Xn_1443}
N 718 28245 698 28245 {lab=n_0840}
C {./lab_pin.sym} 698 28245 0 0 {name=l1502_0 lab=n_0840}
N 718 28265 698 28265 {lab=n_0838}
C {./lab_pin.sym} 698 28265 0 0 {name=l1502_1 lab=n_0838}
N 718 28285 698 28285 {lab=n_0841}
C {./lab_pin.sym} 698 28285 0 0 {name=l1502_2 lab=n_0841}
N 718 28305 698 28305 {lab=n_0842}
C {./lab_pin.sym} 698 28305 0 0 {name=l1502_3 lab=n_0842}
N 902 28245 922 28245 {lab=VDD}
C {./lab_pin.sym} 922 28245 0 1 {name=l1502_4 lab=VDD}
N 902 28265 922 28265 {lab=VDD}
C {./lab_pin.sym} 922 28265 0 1 {name=l1502_5 lab=VDD}
N 902 28285 922 28285 {lab=VSS}
C {./lab_pin.sym} 922 28285 0 1 {name=l1502_6 lab=VSS}
N 902 28305 922 28305 {lab=VSS}
C {./lab_pin.sym} 922 28305 0 1 {name=l1502_7 lab=VSS}
C {./nor4_1.sym} 1215 28275 0 0 {name=Xn_1444}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__nor4_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -60 72 -60 {}
L 4 72 -60 72 60 {}
L 4 72 60 -72 60 {}
L 4 -72 60 -72 -60 {}
T {@name} -72 -80 0 0 0.33 0.33 {}
T {nor4_1} -68 49 0 0 0.2 0.2 {}
L 4 -92 -40 -72 -40 {}
T {A1} -66 -45 0 0 0.16 0.16 {}
L 4 -92 -20 -72 -20 {}
T {A2} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {A3} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {A4} -66 15 0 0 0.16 0.16 {}
L 4 -92 40 -72 40 {}
T {ZN} -66 35 0 0 0.16 0.16 {}
L 4 92 -30 72 -30 {}
T {VDD} 50.2 -35 0 0 0.16 0.16 {}
L 4 92 -10 72 -10 {}
T {VNW} 50.2 -15 0 0 0.16 0.16 {}
L 4 92 10 72 10 {}
T {VPW} 50.2 5 0 0 0.16 0.16 {}
L 4 92 30 72 30 {}
T {VSS} 50.2 25 0 0 0.16 0.16 {}
B 5 -94 -42 -90 -38 {name=A1 dir=inout sim_pinnumber=1}
B 5 -94 -22 -90 -18 {name=A2 dir=inout sim_pinnumber=2}
B 5 -94 -2 -90 2 {name=A3 dir=inout sim_pinnumber=3}
B 5 -94 18 -90 22 {name=A4 dir=inout sim_pinnumber=4}
B 5 -94 38 -90 42 {name=ZN dir=inout sim_pinnumber=5}
B 5 90 -32 94 -28 {name=VDD dir=inout sim_pinnumber=6}
B 5 90 -12 94 -8 {name=VNW dir=inout sim_pinnumber=7}
B 5 90 8 94 12 {name=VPW dir=inout sim_pinnumber=8}
B 5 90 28 94 32 {name=VSS dir=inout sim_pinnumber=9}
]
N 1123 28235 1103 28235 {lab=n_0801}
C {./lab_pin.sym} 1103 28235 0 0 {name=l1503_0 lab=n_0801}
N 1123 28255 1103 28255 {lab=n_0813}
C {./lab_pin.sym} 1103 28255 0 0 {name=l1503_1 lab=n_0813}
N 1123 28275 1103 28275 {lab=n_0837}
C {./lab_pin.sym} 1103 28275 0 0 {name=l1503_2 lab=n_0837}
N 1123 28295 1103 28295 {lab=n_0839}
C {./lab_pin.sym} 1103 28295 0 0 {name=l1503_3 lab=n_0839}
N 1123 28315 1103 28315 {lab=n_0843}
C {./lab_pin.sym} 1103 28315 0 0 {name=l1503_4 lab=n_0843}
N 1307 28245 1327 28245 {lab=VDD}
C {./lab_pin.sym} 1327 28245 0 1 {name=l1503_5 lab=VDD}
N 1307 28265 1327 28265 {lab=VDD}
C {./lab_pin.sym} 1327 28265 0 1 {name=l1503_6 lab=VDD}
N 1307 28285 1327 28285 {lab=VSS}
C {./lab_pin.sym} 1327 28285 0 1 {name=l1503_7 lab=VSS}
N 1307 28305 1327 28305 {lab=VSS}
C {./lab_pin.sym} 1327 28305 0 1 {name=l1503_8 lab=VSS}
C {./nand2_1.sym} 1620 28275 0 0 {name=Xn_1445}
N 1528 28245 1508 28245 {lab=n_0794}
C {./lab_pin.sym} 1508 28245 0 0 {name=l1504_0 lab=n_0794}
N 1528 28265 1508 28265 {lab=n_0843}
C {./lab_pin.sym} 1508 28265 0 0 {name=l1504_1 lab=n_0843}
N 1528 28285 1508 28285 {lab=n_0844}
C {./lab_pin.sym} 1508 28285 0 0 {name=l1504_2 lab=n_0844}
N 1528 28305 1508 28305 {lab=VDD}
C {./lab_pin.sym} 1508 28305 0 0 {name=l1504_3 lab=VDD}
N 1712 28255 1732 28255 {lab=VDD}
C {./lab_pin.sym} 1732 28255 0 1 {name=l1504_4 lab=VDD}
N 1712 28275 1732 28275 {lab=VSS}
C {./lab_pin.sym} 1732 28275 0 1 {name=l1504_5 lab=VSS}
N 1712 28295 1732 28295 {lab=VSS}
C {./lab_pin.sym} 1732 28295 0 1 {name=l1504_6 lab=VSS}
C {./and2_1.sym} 2025 28275 0 0 {name=Xn_1446}
N 1933 28245 1913 28245 {lab=n_0844}
C {./lab_pin.sym} 1913 28245 0 0 {name=l1505_0 lab=n_0844}
N 1933 28265 1913 28265 {lab=n_0842}
C {./lab_pin.sym} 1913 28265 0 0 {name=l1505_1 lab=n_0842}
N 1933 28285 1913 28285 {lab=n_0845}
C {./lab_pin.sym} 1913 28285 0 0 {name=l1505_2 lab=n_0845}
N 1933 28305 1913 28305 {lab=VDD}
C {./lab_pin.sym} 1913 28305 0 0 {name=l1505_3 lab=VDD}
N 2117 28255 2137 28255 {lab=VDD}
C {./lab_pin.sym} 2137 28255 0 1 {name=l1505_4 lab=VDD}
N 2117 28275 2137 28275 {lab=VSS}
C {./lab_pin.sym} 2137 28275 0 1 {name=l1505_5 lab=VSS}
N 2117 28295 2137 28295 {lab=VSS}
C {./lab_pin.sym} 2137 28295 0 1 {name=l1505_6 lab=VSS}
C {./nand2_1.sym} 2430 28275 0 0 {name=Xn_1447}
N 2338 28245 2318 28245 {lab=n_0844}
C {./lab_pin.sym} 2318 28245 0 0 {name=l1506_0 lab=n_0844}
N 2338 28265 2318 28265 {lab=n_0842}
C {./lab_pin.sym} 2318 28265 0 0 {name=l1506_1 lab=n_0842}
N 2338 28285 2318 28285 {lab=n_0846}
C {./lab_pin.sym} 2318 28285 0 0 {name=l1506_2 lab=n_0846}
N 2338 28305 2318 28305 {lab=VDD}
C {./lab_pin.sym} 2318 28305 0 0 {name=l1506_3 lab=VDD}
N 2522 28255 2542 28255 {lab=VDD}
C {./lab_pin.sym} 2542 28255 0 1 {name=l1506_4 lab=VDD}
N 2522 28275 2542 28275 {lab=VSS}
C {./lab_pin.sym} 2542 28275 0 1 {name=l1506_5 lab=VSS}
N 2522 28295 2542 28295 {lab=VSS}
C {./lab_pin.sym} 2542 28295 0 1 {name=l1506_6 lab=VSS}
C {./or2_1.sym} 2835 28275 0 0 {name=Xn_1448}
N 2743 28245 2723 28245 {lab=u_cas_int_out_int2_b16}
C {./lab_pin.sym} 2723 28245 0 0 {name=l1507_0 lab=u_cas_int_out_int2_b16}
N 2743 28265 2723 28265 {lab=u_cas_int_out_int1_b16}
C {./lab_pin.sym} 2723 28265 0 0 {name=l1507_1 lab=u_cas_int_out_int1_b16}
N 2743 28285 2723 28285 {lab=n_0847}
C {./lab_pin.sym} 2723 28285 0 0 {name=l1507_2 lab=n_0847}
N 2743 28305 2723 28305 {lab=VDD}
C {./lab_pin.sym} 2723 28305 0 0 {name=l1507_3 lab=VDD}
N 2927 28255 2947 28255 {lab=VDD}
C {./lab_pin.sym} 2947 28255 0 1 {name=l1507_4 lab=VDD}
N 2927 28275 2947 28275 {lab=VSS}
C {./lab_pin.sym} 2947 28275 0 1 {name=l1507_5 lab=VSS}
N 2927 28295 2947 28295 {lab=VSS}
C {./lab_pin.sym} 2947 28295 0 1 {name=l1507_6 lab=VSS}
C {./nand2_1.sym} 3240 28275 0 0 {name=Xn_1449}
N 3148 28245 3128 28245 {lab=u_cas_int_out_int2_b16}
C {./lab_pin.sym} 3128 28245 0 0 {name=l1508_0 lab=u_cas_int_out_int2_b16}
N 3148 28265 3128 28265 {lab=u_cas_int_out_int1_b16}
C {./lab_pin.sym} 3128 28265 0 0 {name=l1508_1 lab=u_cas_int_out_int1_b16}
N 3148 28285 3128 28285 {lab=n_0848}
C {./lab_pin.sym} 3128 28285 0 0 {name=l1508_2 lab=n_0848}
N 3148 28305 3128 28305 {lab=VDD}
C {./lab_pin.sym} 3128 28305 0 0 {name=l1508_3 lab=VDD}
N 3332 28255 3352 28255 {lab=VDD}
C {./lab_pin.sym} 3352 28255 0 1 {name=l1508_4 lab=VDD}
N 3332 28275 3352 28275 {lab=VSS}
C {./lab_pin.sym} 3352 28275 0 1 {name=l1508_5 lab=VSS}
N 3332 28295 3352 28295 {lab=VSS}
C {./lab_pin.sym} 3352 28295 0 1 {name=l1508_6 lab=VSS}
C {./nand2_1.sym} 3645 28275 0 0 {name=Xn_1450}
N 3553 28245 3533 28245 {lab=n_0847}
C {./lab_pin.sym} 3533 28245 0 0 {name=l1509_0 lab=n_0847}
N 3553 28265 3533 28265 {lab=n_0848}
C {./lab_pin.sym} 3533 28265 0 0 {name=l1509_1 lab=n_0848}
N 3553 28285 3533 28285 {lab=n_0849}
C {./lab_pin.sym} 3533 28285 0 0 {name=l1509_2 lab=n_0849}
N 3553 28305 3533 28305 {lab=VDD}
C {./lab_pin.sym} 3533 28305 0 0 {name=l1509_3 lab=VDD}
N 3737 28255 3757 28255 {lab=VDD}
C {./lab_pin.sym} 3757 28255 0 1 {name=l1509_4 lab=VDD}
N 3737 28275 3757 28275 {lab=VSS}
C {./lab_pin.sym} 3757 28275 0 1 {name=l1509_5 lab=VSS}
N 3737 28295 3757 28295 {lab=VSS}
C {./lab_pin.sym} 3757 28295 0 1 {name=l1509_6 lab=VSS}
C {./aoi21_1.sym} 4050 28275 0 0 {name=Xn_1451}
N 3958 28245 3938 28245 {lab=n_0844}
C {./lab_pin.sym} 3938 28245 0 0 {name=l1510_0 lab=n_0844}
N 3958 28265 3938 28265 {lab=n_0842}
C {./lab_pin.sym} 3938 28265 0 0 {name=l1510_1 lab=n_0842}
N 3958 28285 3938 28285 {lab=n_0849}
C {./lab_pin.sym} 3938 28285 0 0 {name=l1510_2 lab=n_0849}
N 3958 28305 3938 28305 {lab=n_0850}
C {./lab_pin.sym} 3938 28305 0 0 {name=l1510_3 lab=n_0850}
N 4142 28245 4162 28245 {lab=VDD}
C {./lab_pin.sym} 4162 28245 0 1 {name=l1510_4 lab=VDD}
N 4142 28265 4162 28265 {lab=VDD}
C {./lab_pin.sym} 4162 28265 0 1 {name=l1510_5 lab=VDD}
N 4142 28285 4162 28285 {lab=VSS}
C {./lab_pin.sym} 4162 28285 0 1 {name=l1510_6 lab=VSS}
N 4142 28305 4162 28305 {lab=VSS}
C {./lab_pin.sym} 4162 28305 0 1 {name=l1510_7 lab=VSS}
C {./xor2_1.sym} 4455 28275 0 0 {name=Xn_1452}
N 4363 28245 4343 28245 {lab=n_0845}
C {./lab_pin.sym} 4343 28245 0 0 {name=l1511_0 lab=n_0845}
N 4363 28265 4343 28265 {lab=n_0849}
C {./lab_pin.sym} 4343 28265 0 0 {name=l1511_1 lab=n_0849}
N 4363 28285 4343 28285 {lab=n_0094}
C {./lab_pin.sym} 4343 28285 0 0 {name=l1511_2 lab=n_0094}
N 4363 28305 4343 28305 {lab=VDD}
C {./lab_pin.sym} 4343 28305 0 0 {name=l1511_3 lab=VDD}
N 4547 28255 4567 28255 {lab=VDD}
C {./lab_pin.sym} 4567 28255 0 1 {name=l1511_4 lab=VDD}
N 4547 28275 4567 28275 {lab=VSS}
C {./lab_pin.sym} 4567 28275 0 1 {name=l1511_5 lab=VSS}
N 4547 28295 4567 28295 {lab=VSS}
C {./lab_pin.sym} 4567 28295 0 1 {name=l1511_6 lab=VSS}
C {./aoi21_1.sym} 0 28500 0 0 {name=Xn_1453}
N -92 28470 -112 28470 {lab=u_cas_int_out_int2_b16}
C {./lab_pin.sym} -112 28470 0 0 {name=l1512_0 lab=u_cas_int_out_int2_b16}
N -92 28490 -112 28490 {lab=u_cas_int_out_int1_b16}
C {./lab_pin.sym} -112 28490 0 0 {name=l1512_1 lab=u_cas_int_out_int1_b16}
N -92 28510 -112 28510 {lab=n_0850}
C {./lab_pin.sym} -112 28510 0 0 {name=l1512_2 lab=n_0850}
N -92 28530 -112 28530 {lab=n_0851}
C {./lab_pin.sym} -112 28530 0 0 {name=l1512_3 lab=n_0851}
N 92 28470 112 28470 {lab=VDD}
C {./lab_pin.sym} 112 28470 0 1 {name=l1512_4 lab=VDD}
N 92 28490 112 28490 {lab=VDD}
C {./lab_pin.sym} 112 28490 0 1 {name=l1512_5 lab=VDD}
N 92 28510 112 28510 {lab=VSS}
C {./lab_pin.sym} 112 28510 0 1 {name=l1512_6 lab=VSS}
N 92 28530 112 28530 {lab=VSS}
C {./lab_pin.sym} 112 28530 0 1 {name=l1512_7 lab=VSS}
C {./or2_1.sym} 405 28500 0 0 {name=Xn_1454}
N 313 28470 293 28470 {lab=u_cas_int_out_int2_b17}
C {./lab_pin.sym} 293 28470 0 0 {name=l1513_0 lab=u_cas_int_out_int2_b17}
N 313 28490 293 28490 {lab=u_cas_int_out_int1_b17}
C {./lab_pin.sym} 293 28490 0 0 {name=l1513_1 lab=u_cas_int_out_int1_b17}
N 313 28510 293 28510 {lab=n_0852}
C {./lab_pin.sym} 293 28510 0 0 {name=l1513_2 lab=n_0852}
N 313 28530 293 28530 {lab=VDD}
C {./lab_pin.sym} 293 28530 0 0 {name=l1513_3 lab=VDD}
N 497 28480 517 28480 {lab=VDD}
C {./lab_pin.sym} 517 28480 0 1 {name=l1513_4 lab=VDD}
N 497 28500 517 28500 {lab=VSS}
C {./lab_pin.sym} 517 28500 0 1 {name=l1513_5 lab=VSS}
N 497 28520 517 28520 {lab=VSS}
C {./lab_pin.sym} 517 28520 0 1 {name=l1513_6 lab=VSS}
C {./nand2_1.sym} 810 28500 0 0 {name=Xn_1455}
N 718 28470 698 28470 {lab=u_cas_int_out_int2_b17}
C {./lab_pin.sym} 698 28470 0 0 {name=l1514_0 lab=u_cas_int_out_int2_b17}
N 718 28490 698 28490 {lab=u_cas_int_out_int1_b17}
C {./lab_pin.sym} 698 28490 0 0 {name=l1514_1 lab=u_cas_int_out_int1_b17}
N 718 28510 698 28510 {lab=n_0853}
C {./lab_pin.sym} 698 28510 0 0 {name=l1514_2 lab=n_0853}
N 718 28530 698 28530 {lab=VDD}
C {./lab_pin.sym} 698 28530 0 0 {name=l1514_3 lab=VDD}
N 902 28480 922 28480 {lab=VDD}
C {./lab_pin.sym} 922 28480 0 1 {name=l1514_4 lab=VDD}
N 902 28500 922 28500 {lab=VSS}
C {./lab_pin.sym} 922 28500 0 1 {name=l1514_5 lab=VSS}
N 902 28520 922 28520 {lab=VSS}
C {./lab_pin.sym} 922 28520 0 1 {name=l1514_6 lab=VSS}
C {./nand2_1.sym} 1215 28500 0 0 {name=Xn_1456}
N 1123 28470 1103 28470 {lab=n_0852}
C {./lab_pin.sym} 1103 28470 0 0 {name=l1515_0 lab=n_0852}
N 1123 28490 1103 28490 {lab=n_0853}
C {./lab_pin.sym} 1103 28490 0 0 {name=l1515_1 lab=n_0853}
N 1123 28510 1103 28510 {lab=n_0854}
C {./lab_pin.sym} 1103 28510 0 0 {name=l1515_2 lab=n_0854}
N 1123 28530 1103 28530 {lab=VDD}
C {./lab_pin.sym} 1103 28530 0 0 {name=l1515_3 lab=VDD}
N 1307 28480 1327 28480 {lab=VDD}
C {./lab_pin.sym} 1327 28480 0 1 {name=l1515_4 lab=VDD}
N 1307 28500 1327 28500 {lab=VSS}
C {./lab_pin.sym} 1327 28500 0 1 {name=l1515_5 lab=VSS}
N 1307 28520 1327 28520 {lab=VSS}
C {./lab_pin.sym} 1327 28520 0 1 {name=l1515_6 lab=VSS}
C {./xor2_1.sym} 1620 28500 0 0 {name=Xn_1457}
N 1528 28470 1508 28470 {lab=n_0851}
C {./lab_pin.sym} 1508 28470 0 0 {name=l1516_0 lab=n_0851}
N 1528 28490 1508 28490 {lab=n_0854}
C {./lab_pin.sym} 1508 28490 0 0 {name=l1516_1 lab=n_0854}
N 1528 28510 1508 28510 {lab=n_0095}
C {./lab_pin.sym} 1508 28510 0 0 {name=l1516_2 lab=n_0095}
N 1528 28530 1508 28530 {lab=VDD}
C {./lab_pin.sym} 1508 28530 0 0 {name=l1516_3 lab=VDD}
N 1712 28480 1732 28480 {lab=VDD}
C {./lab_pin.sym} 1732 28480 0 1 {name=l1516_4 lab=VDD}
N 1712 28500 1732 28500 {lab=VSS}
C {./lab_pin.sym} 1732 28500 0 1 {name=l1516_5 lab=VSS}
N 1712 28520 1732 28520 {lab=VSS}
C {./lab_pin.sym} 1732 28520 0 1 {name=l1516_6 lab=VSS}
C {./nand2_1.sym} 2025 28500 0 0 {name=Xn_1458}
N 1933 28470 1913 28470 {lab=n_0848}
C {./lab_pin.sym} 1913 28470 0 0 {name=l1517_0 lab=n_0848}
N 1933 28490 1913 28490 {lab=n_0853}
C {./lab_pin.sym} 1913 28490 0 0 {name=l1517_1 lab=n_0853}
N 1933 28510 1913 28510 {lab=n_0855}
C {./lab_pin.sym} 1913 28510 0 0 {name=l1517_2 lab=n_0855}
N 1933 28530 1913 28530 {lab=VDD}
C {./lab_pin.sym} 1913 28530 0 0 {name=l1517_3 lab=VDD}
N 2117 28480 2137 28480 {lab=VDD}
C {./lab_pin.sym} 2137 28480 0 1 {name=l1517_4 lab=VDD}
N 2117 28500 2137 28500 {lab=VSS}
C {./lab_pin.sym} 2137 28500 0 1 {name=l1517_5 lab=VSS}
N 2117 28520 2137 28520 {lab=VSS}
C {./lab_pin.sym} 2137 28520 0 1 {name=l1517_6 lab=VSS}
C {./oai22_1.sym} 2430 28500 0 0 {name=Xn_1459}
N 2338 28460 2318 28460 {lab=n_0850}
C {./lab_pin.sym} 2318 28460 0 0 {name=l1518_0 lab=n_0850}
N 2338 28480 2318 28480 {lab=n_0855}
C {./lab_pin.sym} 2318 28480 0 0 {name=l1518_1 lab=n_0855}
N 2338 28500 2318 28500 {lab=u_cas_int_out_int2_b17}
C {./lab_pin.sym} 2318 28500 0 0 {name=l1518_2 lab=u_cas_int_out_int2_b17}
N 2338 28520 2318 28520 {lab=u_cas_int_out_int1_b17}
C {./lab_pin.sym} 2318 28520 0 0 {name=l1518_3 lab=u_cas_int_out_int1_b17}
N 2338 28540 2318 28540 {lab=n_0856}
C {./lab_pin.sym} 2318 28540 0 0 {name=l1518_4 lab=n_0856}
N 2522 28470 2542 28470 {lab=VDD}
C {./lab_pin.sym} 2542 28470 0 1 {name=l1518_5 lab=VDD}
N 2522 28490 2542 28490 {lab=VDD}
C {./lab_pin.sym} 2542 28490 0 1 {name=l1518_6 lab=VDD}
N 2522 28510 2542 28510 {lab=VSS}
C {./lab_pin.sym} 2542 28510 0 1 {name=l1518_7 lab=VSS}
N 2522 28530 2542 28530 {lab=VSS}
C {./lab_pin.sym} 2542 28530 0 1 {name=l1518_8 lab=VSS}
C {./nand2_1.sym} 2835 28500 0 0 {name=Xn_1460}
N 2743 28470 2723 28470 {lab=u_cas_int_out_int2_b18}
C {./lab_pin.sym} 2723 28470 0 0 {name=l1519_0 lab=u_cas_int_out_int2_b18}
N 2743 28490 2723 28490 {lab=u_cas_int_out_int1_b18}
C {./lab_pin.sym} 2723 28490 0 0 {name=l1519_1 lab=u_cas_int_out_int1_b18}
N 2743 28510 2723 28510 {lab=n_0857}
C {./lab_pin.sym} 2723 28510 0 0 {name=l1519_2 lab=n_0857}
N 2743 28530 2723 28530 {lab=VDD}
C {./lab_pin.sym} 2723 28530 0 0 {name=l1519_3 lab=VDD}
N 2927 28480 2947 28480 {lab=VDD}
C {./lab_pin.sym} 2947 28480 0 1 {name=l1519_4 lab=VDD}
N 2927 28500 2947 28500 {lab=VSS}
C {./lab_pin.sym} 2947 28500 0 1 {name=l1519_5 lab=VSS}
N 2927 28520 2947 28520 {lab=VSS}
C {./lab_pin.sym} 2947 28520 0 1 {name=l1519_6 lab=VSS}
C {./xor2_1.sym} 3240 28500 0 0 {name=Xn_1461}
N 3148 28470 3128 28470 {lab=u_cas_int_out_int2_b18}
C {./lab_pin.sym} 3128 28470 0 0 {name=l1520_0 lab=u_cas_int_out_int2_b18}
N 3148 28490 3128 28490 {lab=u_cas_int_out_int1_b18}
C {./lab_pin.sym} 3128 28490 0 0 {name=l1520_1 lab=u_cas_int_out_int1_b18}
N 3148 28510 3128 28510 {lab=n_0858}
C {./lab_pin.sym} 3128 28510 0 0 {name=l1520_2 lab=n_0858}
N 3148 28530 3128 28530 {lab=VDD}
C {./lab_pin.sym} 3128 28530 0 0 {name=l1520_3 lab=VDD}
N 3332 28480 3352 28480 {lab=VDD}
C {./lab_pin.sym} 3352 28480 0 1 {name=l1520_4 lab=VDD}
N 3332 28500 3352 28500 {lab=VSS}
C {./lab_pin.sym} 3352 28500 0 1 {name=l1520_5 lab=VSS}
N 3332 28520 3352 28520 {lab=VSS}
C {./lab_pin.sym} 3352 28520 0 1 {name=l1520_6 lab=VSS}
C {./oai211_1.sym} 3645 28500 0 0 {name=Xn_1462}
N 3553 28460 3533 28460 {lab=n_0850}
C {./lab_pin.sym} 3533 28460 0 0 {name=l1521_0 lab=n_0850}
N 3553 28480 3533 28480 {lab=n_0855}
C {./lab_pin.sym} 3533 28480 0 0 {name=l1521_1 lab=n_0855}
N 3553 28500 3533 28500 {lab=n_0858}
C {./lab_pin.sym} 3533 28500 0 0 {name=l1521_2 lab=n_0858}
N 3553 28520 3533 28520 {lab=n_0852}
C {./lab_pin.sym} 3533 28520 0 0 {name=l1521_3 lab=n_0852}
N 3553 28540 3533 28540 {lab=n_0859}
C {./lab_pin.sym} 3533 28540 0 0 {name=l1521_4 lab=n_0859}
N 3737 28470 3757 28470 {lab=VDD}
C {./lab_pin.sym} 3757 28470 0 1 {name=l1521_5 lab=VDD}
N 3737 28490 3757 28490 {lab=VDD}
C {./lab_pin.sym} 3757 28490 0 1 {name=l1521_6 lab=VDD}
N 3737 28510 3757 28510 {lab=VSS}
C {./lab_pin.sym} 3757 28510 0 1 {name=l1521_7 lab=VSS}
N 3737 28530 3757 28530 {lab=VSS}
C {./lab_pin.sym} 3757 28530 0 1 {name=l1521_8 lab=VSS}
C {./xnor2_1.sym} 4050 28500 0 0 {name=Xn_1463}
N 3958 28470 3938 28470 {lab=n_0856}
C {./lab_pin.sym} 3938 28470 0 0 {name=l1522_0 lab=n_0856}
N 3958 28490 3938 28490 {lab=n_0858}
C {./lab_pin.sym} 3938 28490 0 0 {name=l1522_1 lab=n_0858}
N 3958 28510 3938 28510 {lab=n_0096}
C {./lab_pin.sym} 3938 28510 0 0 {name=l1522_2 lab=n_0096}
N 3958 28530 3938 28530 {lab=VDD}
C {./lab_pin.sym} 3938 28530 0 0 {name=l1522_3 lab=VDD}
N 4142 28480 4162 28480 {lab=VDD}
C {./lab_pin.sym} 4162 28480 0 1 {name=l1522_4 lab=VDD}
N 4142 28500 4162 28500 {lab=VSS}
C {./lab_pin.sym} 4162 28500 0 1 {name=l1522_5 lab=VSS}
N 4142 28520 4162 28520 {lab=VSS}
C {./lab_pin.sym} 4162 28520 0 1 {name=l1522_6 lab=VSS}
C {./nand2_1.sym} 4455 28500 0 0 {name=Xn_1464}
N 4363 28470 4343 28470 {lab=u_cas_int_out_int2_b19}
C {./lab_pin.sym} 4343 28470 0 0 {name=l1523_0 lab=u_cas_int_out_int2_b19}
N 4363 28490 4343 28490 {lab=u_cas_int_out_int1_b19}
C {./lab_pin.sym} 4343 28490 0 0 {name=l1523_1 lab=u_cas_int_out_int1_b19}
N 4363 28510 4343 28510 {lab=n_0860}
C {./lab_pin.sym} 4343 28510 0 0 {name=l1523_2 lab=n_0860}
N 4363 28530 4343 28530 {lab=VDD}
C {./lab_pin.sym} 4343 28530 0 0 {name=l1523_3 lab=VDD}
N 4547 28480 4567 28480 {lab=VDD}
C {./lab_pin.sym} 4567 28480 0 1 {name=l1523_4 lab=VDD}
N 4547 28500 4567 28500 {lab=VSS}
C {./lab_pin.sym} 4567 28500 0 1 {name=l1523_5 lab=VSS}
N 4547 28520 4567 28520 {lab=VSS}
C {./lab_pin.sym} 4567 28520 0 1 {name=l1523_6 lab=VSS}
C {./xor2_1.sym} 0 28725 0 0 {name=Xn_1465}
N -92 28695 -112 28695 {lab=u_cas_int_out_int2_b19}
C {./lab_pin.sym} -112 28695 0 0 {name=l1524_0 lab=u_cas_int_out_int2_b19}
N -92 28715 -112 28715 {lab=u_cas_int_out_int1_b19}
C {./lab_pin.sym} -112 28715 0 0 {name=l1524_1 lab=u_cas_int_out_int1_b19}
N -92 28735 -112 28735 {lab=n_0861}
C {./lab_pin.sym} -112 28735 0 0 {name=l1524_2 lab=n_0861}
N -92 28755 -112 28755 {lab=VDD}
C {./lab_pin.sym} -112 28755 0 0 {name=l1524_3 lab=VDD}
N 92 28705 112 28705 {lab=VDD}
C {./lab_pin.sym} 112 28705 0 1 {name=l1524_4 lab=VDD}
N 92 28725 112 28725 {lab=VSS}
C {./lab_pin.sym} 112 28725 0 1 {name=l1524_5 lab=VSS}
N 92 28745 112 28745 {lab=VSS}
C {./lab_pin.sym} 112 28745 0 1 {name=l1524_6 lab=VSS}
C {./nand2_1.sym} 405 28725 0 0 {name=Xn_1466}
N 313 28695 293 28695 {lab=n_0857}
C {./lab_pin.sym} 293 28695 0 0 {name=l1525_0 lab=n_0857}
N 313 28715 293 28715 {lab=n_0859}
C {./lab_pin.sym} 293 28715 0 0 {name=l1525_1 lab=n_0859}
N 313 28735 293 28735 {lab=n_0862}
C {./lab_pin.sym} 293 28735 0 0 {name=l1525_2 lab=n_0862}
N 313 28755 293 28755 {lab=VDD}
C {./lab_pin.sym} 293 28755 0 0 {name=l1525_3 lab=VDD}
N 497 28705 517 28705 {lab=VDD}
C {./lab_pin.sym} 517 28705 0 1 {name=l1525_4 lab=VDD}
N 497 28725 517 28725 {lab=VSS}
C {./lab_pin.sym} 517 28725 0 1 {name=l1525_5 lab=VSS}
N 497 28745 517 28745 {lab=VSS}
C {./lab_pin.sym} 517 28745 0 1 {name=l1525_6 lab=VSS}
C {./xor2_1.sym} 810 28725 0 0 {name=Xn_1467}
N 718 28695 698 28695 {lab=n_0861}
C {./lab_pin.sym} 698 28695 0 0 {name=l1526_0 lab=n_0861}
N 718 28715 698 28715 {lab=n_0862}
C {./lab_pin.sym} 698 28715 0 0 {name=l1526_1 lab=n_0862}
N 718 28735 698 28735 {lab=n_0097}
C {./lab_pin.sym} 698 28735 0 0 {name=l1526_2 lab=n_0097}
N 718 28755 698 28755 {lab=VDD}
C {./lab_pin.sym} 698 28755 0 0 {name=l1526_3 lab=VDD}
N 902 28705 922 28705 {lab=VDD}
C {./lab_pin.sym} 922 28705 0 1 {name=l1526_4 lab=VDD}
N 902 28725 922 28725 {lab=VSS}
C {./lab_pin.sym} 922 28725 0 1 {name=l1526_5 lab=VSS}
N 902 28745 922 28745 {lab=VSS}
C {./lab_pin.sym} 922 28745 0 1 {name=l1526_6 lab=VSS}
C {./nand2_1.sym} 1215 28725 0 0 {name=Xn_1468}
N 1123 28695 1103 28695 {lab=n_0858}
C {./lab_pin.sym} 1103 28695 0 0 {name=l1527_0 lab=n_0858}
N 1123 28715 1103 28715 {lab=n_0861}
C {./lab_pin.sym} 1103 28715 0 0 {name=l1527_1 lab=n_0861}
N 1123 28735 1103 28735 {lab=n_0863}
C {./lab_pin.sym} 1103 28735 0 0 {name=l1527_2 lab=n_0863}
N 1123 28755 1103 28755 {lab=VDD}
C {./lab_pin.sym} 1103 28755 0 0 {name=l1527_3 lab=VDD}
N 1307 28705 1327 28705 {lab=VDD}
C {./lab_pin.sym} 1327 28705 0 1 {name=l1527_4 lab=VDD}
N 1307 28725 1327 28725 {lab=VSS}
C {./lab_pin.sym} 1327 28725 0 1 {name=l1527_5 lab=VSS}
N 1307 28745 1327 28745 {lab=VSS}
C {./lab_pin.sym} 1327 28745 0 1 {name=l1527_6 lab=VSS}
C {./nor3_1.sym} 1620 28725 0 0 {name=Xn_1469}
N 1528 28695 1508 28695 {lab=n_0849}
C {./lab_pin.sym} 1508 28695 0 0 {name=l1528_0 lab=n_0849}
N 1528 28715 1508 28715 {lab=n_0854}
C {./lab_pin.sym} 1508 28715 0 0 {name=l1528_1 lab=n_0854}
N 1528 28735 1508 28735 {lab=n_0863}
C {./lab_pin.sym} 1508 28735 0 0 {name=l1528_2 lab=n_0863}
N 1528 28755 1508 28755 {lab=n_0864}
C {./lab_pin.sym} 1508 28755 0 0 {name=l1528_3 lab=n_0864}
N 1712 28695 1732 28695 {lab=VDD}
C {./lab_pin.sym} 1732 28695 0 1 {name=l1528_4 lab=VDD}
N 1712 28715 1732 28715 {lab=VDD}
C {./lab_pin.sym} 1732 28715 0 1 {name=l1528_5 lab=VDD}
N 1712 28735 1732 28735 {lab=VSS}
C {./lab_pin.sym} 1732 28735 0 1 {name=l1528_6 lab=VSS}
N 1712 28755 1732 28755 {lab=VSS}
C {./lab_pin.sym} 1732 28755 0 1 {name=l1528_7 lab=VSS}
C {./clkinv_1.sym} 2025 28725 0 0 {name=Xn_1470}
N 1933 28705 1913 28705 {lab=n_0864}
C {./lab_pin.sym} 1913 28705 0 0 {name=l1529_0 lab=n_0864}
N 1933 28725 1913 28725 {lab=n_0865}
C {./lab_pin.sym} 1913 28725 0 0 {name=l1529_1 lab=n_0865}
N 1933 28745 1913 28745 {lab=VDD}
C {./lab_pin.sym} 1913 28745 0 0 {name=l1529_2 lab=VDD}
N 2117 28705 2137 28705 {lab=VDD}
C {./lab_pin.sym} 2137 28705 0 1 {name=l1529_3 lab=VDD}
N 2117 28725 2137 28725 {lab=VSS}
C {./lab_pin.sym} 2137 28725 0 1 {name=l1529_4 lab=VSS}
N 2117 28745 2137 28745 {lab=VSS}
C {./lab_pin.sym} 2137 28745 0 1 {name=l1529_5 lab=VSS}
C {./aoi21_1.sym} 2430 28725 0 0 {name=Xn_1471}
N 2338 28695 2318 28695 {lab=n_0844}
C {./lab_pin.sym} 2318 28695 0 0 {name=l1530_0 lab=n_0844}
N 2338 28715 2318 28715 {lab=n_0842}
C {./lab_pin.sym} 2318 28715 0 0 {name=l1530_1 lab=n_0842}
N 2338 28735 2318 28735 {lab=n_0865}
C {./lab_pin.sym} 2318 28735 0 0 {name=l1530_2 lab=n_0865}
N 2338 28755 2318 28755 {lab=n_0866}
C {./lab_pin.sym} 2318 28755 0 0 {name=l1530_3 lab=n_0866}
N 2522 28695 2542 28695 {lab=VDD}
C {./lab_pin.sym} 2542 28695 0 1 {name=l1530_4 lab=VDD}
N 2522 28715 2542 28715 {lab=VDD}
C {./lab_pin.sym} 2542 28715 0 1 {name=l1530_5 lab=VDD}
N 2522 28735 2542 28735 {lab=VSS}
C {./lab_pin.sym} 2542 28735 0 1 {name=l1530_6 lab=VSS}
N 2522 28755 2542 28755 {lab=VSS}
C {./lab_pin.sym} 2542 28755 0 1 {name=l1530_7 lab=VSS}
C {./nand4_1.sym} 2835 28725 0 0 {name=Xn_1472}
N 2743 28685 2723 28685 {lab=n_0858}
C {./lab_pin.sym} 2723 28685 0 0 {name=l1531_0 lab=n_0858}
N 2743 28705 2723 28705 {lab=n_0861}
C {./lab_pin.sym} 2723 28705 0 0 {name=l1531_1 lab=n_0861}
N 2743 28725 2723 28725 {lab=n_0852}
C {./lab_pin.sym} 2723 28725 0 0 {name=l1531_2 lab=n_0852}
N 2743 28745 2723 28745 {lab=n_0855}
C {./lab_pin.sym} 2723 28745 0 0 {name=l1531_3 lab=n_0855}
N 2743 28765 2723 28765 {lab=n_0867}
C {./lab_pin.sym} 2723 28765 0 0 {name=l1531_4 lab=n_0867}
N 2927 28695 2947 28695 {lab=VDD}
C {./lab_pin.sym} 2947 28695 0 1 {name=l1531_5 lab=VDD}
N 2927 28715 2947 28715 {lab=VDD}
C {./lab_pin.sym} 2947 28715 0 1 {name=l1531_6 lab=VDD}
N 2927 28735 2947 28735 {lab=VSS}
C {./lab_pin.sym} 2947 28735 0 1 {name=l1531_7 lab=VSS}
N 2927 28755 2947 28755 {lab=VSS}
C {./lab_pin.sym} 2947 28755 0 1 {name=l1531_8 lab=VSS}
C {./oai211_1.sym} 3240 28725 0 0 {name=Xn_1473}
N 3148 28685 3128 28685 {lab=u_cas_int_out_int2_b19}
C {./lab_pin.sym} 3128 28685 0 0 {name=l1532_0 lab=u_cas_int_out_int2_b19}
N 3148 28705 3128 28705 {lab=u_cas_int_out_int1_b19}
C {./lab_pin.sym} 3128 28705 0 0 {name=l1532_1 lab=u_cas_int_out_int1_b19}
N 3148 28725 3128 28725 {lab=u_cas_int_out_int1_b18}
C {./lab_pin.sym} 3128 28725 0 0 {name=l1532_2 lab=u_cas_int_out_int1_b18}
N 3148 28745 3128 28745 {lab=u_cas_int_out_int2_b18}
C {./lab_pin.sym} 3128 28745 0 0 {name=l1532_3 lab=u_cas_int_out_int2_b18}
N 3148 28765 3128 28765 {lab=n_0868}
C {./lab_pin.sym} 3128 28765 0 0 {name=l1532_4 lab=n_0868}
N 3332 28695 3352 28695 {lab=VDD}
C {./lab_pin.sym} 3352 28695 0 1 {name=l1532_5 lab=VDD}
N 3332 28715 3352 28715 {lab=VDD}
C {./lab_pin.sym} 3352 28715 0 1 {name=l1532_6 lab=VDD}
N 3332 28735 3352 28735 {lab=VSS}
C {./lab_pin.sym} 3352 28735 0 1 {name=l1532_7 lab=VSS}
N 3332 28755 3352 28755 {lab=VSS}
C {./lab_pin.sym} 3352 28755 0 1 {name=l1532_8 lab=VSS}
C {./and3_1.sym} 3645 28725 0 0 {name=Xn_1474}
N 3553 28695 3533 28695 {lab=n_0860}
C {./lab_pin.sym} 3533 28695 0 0 {name=l1533_0 lab=n_0860}
N 3553 28715 3533 28715 {lab=n_0867}
C {./lab_pin.sym} 3533 28715 0 0 {name=l1533_1 lab=n_0867}
N 3553 28735 3533 28735 {lab=n_0868}
C {./lab_pin.sym} 3533 28735 0 0 {name=l1533_2 lab=n_0868}
N 3553 28755 3533 28755 {lab=n_0869}
C {./lab_pin.sym} 3533 28755 0 0 {name=l1533_3 lab=n_0869}
N 3737 28695 3757 28695 {lab=VDD}
C {./lab_pin.sym} 3757 28695 0 1 {name=l1533_4 lab=VDD}
N 3737 28715 3757 28715 {lab=VDD}
C {./lab_pin.sym} 3757 28715 0 1 {name=l1533_5 lab=VDD}
N 3737 28735 3757 28735 {lab=VSS}
C {./lab_pin.sym} 3757 28735 0 1 {name=l1533_6 lab=VSS}
N 3737 28755 3757 28755 {lab=VSS}
C {./lab_pin.sym} 3757 28755 0 1 {name=l1533_7 lab=VSS}
C {./nand3_1.sym} 4050 28725 0 0 {name=Xn_1475}
N 3958 28695 3938 28695 {lab=n_0860}
C {./lab_pin.sym} 3938 28695 0 0 {name=l1534_0 lab=n_0860}
N 3958 28715 3938 28715 {lab=n_0867}
C {./lab_pin.sym} 3938 28715 0 0 {name=l1534_1 lab=n_0867}
N 3958 28735 3938 28735 {lab=n_0868}
C {./lab_pin.sym} 3938 28735 0 0 {name=l1534_2 lab=n_0868}
N 3958 28755 3938 28755 {lab=n_0870}
C {./lab_pin.sym} 3938 28755 0 0 {name=l1534_3 lab=n_0870}
N 4142 28695 4162 28695 {lab=VDD}
C {./lab_pin.sym} 4162 28695 0 1 {name=l1534_4 lab=VDD}
N 4142 28715 4162 28715 {lab=VDD}
C {./lab_pin.sym} 4162 28715 0 1 {name=l1534_5 lab=VDD}
N 4142 28735 4162 28735 {lab=VSS}
C {./lab_pin.sym} 4162 28735 0 1 {name=l1534_6 lab=VSS}
N 4142 28755 4162 28755 {lab=VSS}
C {./lab_pin.sym} 4162 28755 0 1 {name=l1534_7 lab=VSS}
C {./aoi21_1.sym} 4455 28725 0 0 {name=Xn_1476}
N 4363 28695 4343 28695 {lab=n_0846}
C {./lab_pin.sym} 4343 28695 0 0 {name=l1535_0 lab=n_0846}
N 4363 28715 4343 28715 {lab=n_0864}
C {./lab_pin.sym} 4343 28715 0 0 {name=l1535_1 lab=n_0864}
N 4363 28735 4343 28735 {lab=n_0870}
C {./lab_pin.sym} 4343 28735 0 0 {name=l1535_2 lab=n_0870}
N 4363 28755 4343 28755 {lab=n_0871}
C {./lab_pin.sym} 4343 28755 0 0 {name=l1535_3 lab=n_0871}
N 4547 28695 4567 28695 {lab=VDD}
C {./lab_pin.sym} 4567 28695 0 1 {name=l1535_4 lab=VDD}
N 4547 28715 4567 28715 {lab=VDD}
C {./lab_pin.sym} 4567 28715 0 1 {name=l1535_5 lab=VDD}
N 4547 28735 4567 28735 {lab=VSS}
C {./lab_pin.sym} 4567 28735 0 1 {name=l1535_6 lab=VSS}
N 4547 28755 4567 28755 {lab=VSS}
C {./lab_pin.sym} 4567 28755 0 1 {name=l1535_7 lab=VSS}
C {./oai21_1.sym} 0 28950 0 0 {name=Xn_1477}
N -92 28920 -112 28920 {lab=n_0845}
C {./lab_pin.sym} -112 28920 0 0 {name=l1536_0 lab=n_0845}
N -92 28940 -112 28940 {lab=n_0865}
C {./lab_pin.sym} -112 28940 0 0 {name=l1536_1 lab=n_0865}
N -92 28960 -112 28960 {lab=n_0869}
C {./lab_pin.sym} -112 28960 0 0 {name=l1536_2 lab=n_0869}
N -92 28980 -112 28980 {lab=n_0872}
C {./lab_pin.sym} -112 28980 0 0 {name=l1536_3 lab=n_0872}
N 92 28920 112 28920 {lab=VDD}
C {./lab_pin.sym} 112 28920 0 1 {name=l1536_4 lab=VDD}
N 92 28940 112 28940 {lab=VDD}
C {./lab_pin.sym} 112 28940 0 1 {name=l1536_5 lab=VDD}
N 92 28960 112 28960 {lab=VSS}
C {./lab_pin.sym} 112 28960 0 1 {name=l1536_6 lab=VSS}
N 92 28980 112 28980 {lab=VSS}
C {./lab_pin.sym} 112 28980 0 1 {name=l1536_7 lab=VSS}
C {./or2_1.sym} 405 28950 0 0 {name=Xn_1478}
N 313 28920 293 28920 {lab=u_cas_int_out_int2_b20}
C {./lab_pin.sym} 293 28920 0 0 {name=l1537_0 lab=u_cas_int_out_int2_b20}
N 313 28940 293 28940 {lab=u_cas_int_out_int1_b20}
C {./lab_pin.sym} 293 28940 0 0 {name=l1537_1 lab=u_cas_int_out_int1_b20}
N 313 28960 293 28960 {lab=n_0873}
C {./lab_pin.sym} 293 28960 0 0 {name=l1537_2 lab=n_0873}
N 313 28980 293 28980 {lab=VDD}
C {./lab_pin.sym} 293 28980 0 0 {name=l1537_3 lab=VDD}
N 497 28930 517 28930 {lab=VDD}
C {./lab_pin.sym} 517 28930 0 1 {name=l1537_4 lab=VDD}
N 497 28950 517 28950 {lab=VSS}
C {./lab_pin.sym} 517 28950 0 1 {name=l1537_5 lab=VSS}
N 497 28970 517 28970 {lab=VSS}
C {./lab_pin.sym} 517 28970 0 1 {name=l1537_6 lab=VSS}
C {./nand2_1.sym} 810 28950 0 0 {name=Xn_1479}
N 718 28920 698 28920 {lab=u_cas_int_out_int2_b20}
C {./lab_pin.sym} 698 28920 0 0 {name=l1538_0 lab=u_cas_int_out_int2_b20}
N 718 28940 698 28940 {lab=u_cas_int_out_int1_b20}
C {./lab_pin.sym} 698 28940 0 0 {name=l1538_1 lab=u_cas_int_out_int1_b20}
N 718 28960 698 28960 {lab=n_0874}
C {./lab_pin.sym} 698 28960 0 0 {name=l1538_2 lab=n_0874}
N 718 28980 698 28980 {lab=VDD}
C {./lab_pin.sym} 698 28980 0 0 {name=l1538_3 lab=VDD}
N 902 28930 922 28930 {lab=VDD}
C {./lab_pin.sym} 922 28930 0 1 {name=l1538_4 lab=VDD}
N 902 28950 922 28950 {lab=VSS}
C {./lab_pin.sym} 922 28950 0 1 {name=l1538_5 lab=VSS}
N 902 28970 922 28970 {lab=VSS}
C {./lab_pin.sym} 922 28970 0 1 {name=l1538_6 lab=VSS}
C {./nand2_1.sym} 1215 28950 0 0 {name=Xn_1480}
N 1123 28920 1103 28920 {lab=n_0873}
C {./lab_pin.sym} 1103 28920 0 0 {name=l1539_0 lab=n_0873}
N 1123 28940 1103 28940 {lab=n_0874}
C {./lab_pin.sym} 1103 28940 0 0 {name=l1539_1 lab=n_0874}
N 1123 28960 1103 28960 {lab=n_0875}
C {./lab_pin.sym} 1103 28960 0 0 {name=l1539_2 lab=n_0875}
N 1123 28980 1103 28980 {lab=VDD}
C {./lab_pin.sym} 1103 28980 0 0 {name=l1539_3 lab=VDD}
N 1307 28930 1327 28930 {lab=VDD}
C {./lab_pin.sym} 1327 28930 0 1 {name=l1539_4 lab=VDD}
N 1307 28950 1327 28950 {lab=VSS}
C {./lab_pin.sym} 1327 28950 0 1 {name=l1539_5 lab=VSS}
N 1307 28970 1327 28970 {lab=VSS}
C {./lab_pin.sym} 1327 28970 0 1 {name=l1539_6 lab=VSS}
C {./xor2_1.sym} 1620 28950 0 0 {name=Xn_1481}
N 1528 28920 1508 28920 {lab=n_0871}
C {./lab_pin.sym} 1508 28920 0 0 {name=l1540_0 lab=n_0871}
N 1528 28940 1508 28940 {lab=n_0875}
C {./lab_pin.sym} 1508 28940 0 0 {name=l1540_1 lab=n_0875}
N 1528 28960 1508 28960 {lab=n_0099}
C {./lab_pin.sym} 1508 28960 0 0 {name=l1540_2 lab=n_0099}
N 1528 28980 1508 28980 {lab=VDD}
C {./lab_pin.sym} 1508 28980 0 0 {name=l1540_3 lab=VDD}
N 1712 28930 1732 28930 {lab=VDD}
C {./lab_pin.sym} 1732 28930 0 1 {name=l1540_4 lab=VDD}
N 1712 28950 1732 28950 {lab=VSS}
C {./lab_pin.sym} 1732 28950 0 1 {name=l1540_5 lab=VSS}
N 1712 28970 1732 28970 {lab=VSS}
C {./lab_pin.sym} 1732 28970 0 1 {name=l1540_6 lab=VSS}
C {./or2_1.sym} 2025 28950 0 0 {name=Xn_1482}
N 1933 28920 1913 28920 {lab=u_cas_int_out_int2_b21}
C {./lab_pin.sym} 1913 28920 0 0 {name=l1541_0 lab=u_cas_int_out_int2_b21}
N 1933 28940 1913 28940 {lab=u_cas_int_out_int1_b21}
C {./lab_pin.sym} 1913 28940 0 0 {name=l1541_1 lab=u_cas_int_out_int1_b21}
N 1933 28960 1913 28960 {lab=n_0876}
C {./lab_pin.sym} 1913 28960 0 0 {name=l1541_2 lab=n_0876}
N 1933 28980 1913 28980 {lab=VDD}
C {./lab_pin.sym} 1913 28980 0 0 {name=l1541_3 lab=VDD}
N 2117 28930 2137 28930 {lab=VDD}
C {./lab_pin.sym} 2137 28930 0 1 {name=l1541_4 lab=VDD}
N 2117 28950 2137 28950 {lab=VSS}
C {./lab_pin.sym} 2137 28950 0 1 {name=l1541_5 lab=VSS}
N 2117 28970 2137 28970 {lab=VSS}
C {./lab_pin.sym} 2137 28970 0 1 {name=l1541_6 lab=VSS}
C {./nand2_1.sym} 2430 28950 0 0 {name=Xn_1483}
N 2338 28920 2318 28920 {lab=u_cas_int_out_int2_b21}
C {./lab_pin.sym} 2318 28920 0 0 {name=l1542_0 lab=u_cas_int_out_int2_b21}
N 2338 28940 2318 28940 {lab=u_cas_int_out_int1_b21}
C {./lab_pin.sym} 2318 28940 0 0 {name=l1542_1 lab=u_cas_int_out_int1_b21}
N 2338 28960 2318 28960 {lab=n_0877}
C {./lab_pin.sym} 2318 28960 0 0 {name=l1542_2 lab=n_0877}
N 2338 28980 2318 28980 {lab=VDD}
C {./lab_pin.sym} 2318 28980 0 0 {name=l1542_3 lab=VDD}
N 2522 28930 2542 28930 {lab=VDD}
C {./lab_pin.sym} 2542 28930 0 1 {name=l1542_4 lab=VDD}
N 2522 28950 2542 28950 {lab=VSS}
C {./lab_pin.sym} 2542 28950 0 1 {name=l1542_5 lab=VSS}
N 2522 28970 2542 28970 {lab=VSS}
C {./lab_pin.sym} 2542 28970 0 1 {name=l1542_6 lab=VSS}
C {./oai21_1.sym} 2835 28950 0 0 {name=Xn_1484}
N 2743 28920 2723 28920 {lab=n_0871}
C {./lab_pin.sym} 2723 28920 0 0 {name=l1543_0 lab=n_0871}
N 2743 28940 2723 28940 {lab=n_0875}
C {./lab_pin.sym} 2723 28940 0 0 {name=l1543_1 lab=n_0875}
N 2743 28960 2723 28960 {lab=n_0874}
C {./lab_pin.sym} 2723 28960 0 0 {name=l1543_2 lab=n_0874}
N 2743 28980 2723 28980 {lab=n_0878}
C {./lab_pin.sym} 2723 28980 0 0 {name=l1543_3 lab=n_0878}
N 2927 28920 2947 28920 {lab=VDD}
C {./lab_pin.sym} 2947 28920 0 1 {name=l1543_4 lab=VDD}
N 2927 28940 2947 28940 {lab=VDD}
C {./lab_pin.sym} 2947 28940 0 1 {name=l1543_5 lab=VDD}
N 2927 28960 2947 28960 {lab=VSS}
C {./lab_pin.sym} 2947 28960 0 1 {name=l1543_6 lab=VSS}
N 2927 28980 2947 28980 {lab=VSS}
C {./lab_pin.sym} 2947 28980 0 1 {name=l1543_7 lab=VSS}
C {./xor3_1.sym} 3240 28950 0 0 {name=Xn_1485}
N 3148 28920 3128 28920 {lab=u_cas_int_out_int2_b21}
C {./lab_pin.sym} 3128 28920 0 0 {name=l1544_0 lab=u_cas_int_out_int2_b21}
N 3148 28940 3128 28940 {lab=u_cas_int_out_int1_b21}
C {./lab_pin.sym} 3128 28940 0 0 {name=l1544_1 lab=u_cas_int_out_int1_b21}
N 3148 28960 3128 28960 {lab=n_0878}
C {./lab_pin.sym} 3128 28960 0 0 {name=l1544_2 lab=n_0878}
N 3148 28980 3128 28980 {lab=n_0100}
C {./lab_pin.sym} 3128 28980 0 0 {name=l1544_3 lab=n_0100}
N 3332 28920 3352 28920 {lab=VDD}
C {./lab_pin.sym} 3352 28920 0 1 {name=l1544_4 lab=VDD}
N 3332 28940 3352 28940 {lab=VDD}
C {./lab_pin.sym} 3352 28940 0 1 {name=l1544_5 lab=VDD}
N 3332 28960 3352 28960 {lab=VSS}
C {./lab_pin.sym} 3352 28960 0 1 {name=l1544_6 lab=VSS}
N 3332 28980 3352 28980 {lab=VSS}
C {./lab_pin.sym} 3352 28980 0 1 {name=l1544_7 lab=VSS}
C {./and4_1.sym} 3645 28950 0 0 {name=Xn_1486}
N 3553 28910 3533 28910 {lab=n_0873}
C {./lab_pin.sym} 3533 28910 0 0 {name=l1545_0 lab=n_0873}
N 3553 28930 3533 28930 {lab=n_0874}
C {./lab_pin.sym} 3533 28930 0 0 {name=l1545_1 lab=n_0874}
N 3553 28950 3533 28950 {lab=n_0876}
C {./lab_pin.sym} 3533 28950 0 0 {name=l1545_2 lab=n_0876}
N 3553 28970 3533 28970 {lab=n_0877}
C {./lab_pin.sym} 3533 28970 0 0 {name=l1545_3 lab=n_0877}
N 3553 28990 3533 28990 {lab=n_0879}
C {./lab_pin.sym} 3533 28990 0 0 {name=l1545_4 lab=n_0879}
N 3737 28920 3757 28920 {lab=VDD}
C {./lab_pin.sym} 3757 28920 0 1 {name=l1545_5 lab=VDD}
N 3737 28940 3757 28940 {lab=VDD}
C {./lab_pin.sym} 3757 28940 0 1 {name=l1545_6 lab=VDD}
N 3737 28960 3757 28960 {lab=VSS}
C {./lab_pin.sym} 3757 28960 0 1 {name=l1545_7 lab=VSS}
N 3737 28980 3757 28980 {lab=VSS}
C {./lab_pin.sym} 3757 28980 0 1 {name=l1545_8 lab=VSS}
C {./oai21_1.sym} 4050 28950 0 0 {name=Xn_1487}
N 3958 28920 3938 28920 {lab=n_0866}
C {./lab_pin.sym} 3938 28920 0 0 {name=l1546_0 lab=n_0866}
N 3958 28940 3938 28940 {lab=n_0870}
C {./lab_pin.sym} 3938 28940 0 0 {name=l1546_1 lab=n_0870}
N 3958 28960 3938 28960 {lab=n_0879}
C {./lab_pin.sym} 3938 28960 0 0 {name=l1546_2 lab=n_0879}
N 3958 28980 3938 28980 {lab=n_0880}
C {./lab_pin.sym} 3938 28980 0 0 {name=l1546_3 lab=n_0880}
N 4142 28920 4162 28920 {lab=VDD}
C {./lab_pin.sym} 4162 28920 0 1 {name=l1546_4 lab=VDD}
N 4142 28940 4162 28940 {lab=VDD}
C {./lab_pin.sym} 4162 28940 0 1 {name=l1546_5 lab=VDD}
N 4142 28960 4162 28960 {lab=VSS}
C {./lab_pin.sym} 4162 28960 0 1 {name=l1546_6 lab=VSS}
N 4142 28980 4162 28980 {lab=VSS}
C {./lab_pin.sym} 4162 28980 0 1 {name=l1546_7 lab=VSS}
C {./nand3_1.sym} 4455 28950 0 0 {name=Xn_1488}
N 4363 28920 4343 28920 {lab=n_0876}
C {./lab_pin.sym} 4343 28920 0 0 {name=l1547_0 lab=n_0876}
N 4363 28940 4343 28940 {lab=u_cas_int_out_int1_b20}
C {./lab_pin.sym} 4343 28940 0 0 {name=l1547_1 lab=u_cas_int_out_int1_b20}
N 4363 28960 4343 28960 {lab=u_cas_int_out_int2_b20}
C {./lab_pin.sym} 4343 28960 0 0 {name=l1547_2 lab=u_cas_int_out_int2_b20}
N 4363 28980 4343 28980 {lab=n_0881}
C {./lab_pin.sym} 4343 28980 0 0 {name=l1547_3 lab=n_0881}
N 4547 28920 4567 28920 {lab=VDD}
C {./lab_pin.sym} 4567 28920 0 1 {name=l1547_4 lab=VDD}
N 4547 28940 4567 28940 {lab=VDD}
C {./lab_pin.sym} 4567 28940 0 1 {name=l1547_5 lab=VDD}
N 4547 28960 4567 28960 {lab=VSS}
C {./lab_pin.sym} 4567 28960 0 1 {name=l1547_6 lab=VSS}
N 4547 28980 4567 28980 {lab=VSS}
C {./lab_pin.sym} 4567 28980 0 1 {name=l1547_7 lab=VSS}
C {./and2_1.sym} 0 29175 0 0 {name=Xn_1489}
N -92 29145 -112 29145 {lab=n_0877}
C {./lab_pin.sym} -112 29145 0 0 {name=l1548_0 lab=n_0877}
N -92 29165 -112 29165 {lab=n_0881}
C {./lab_pin.sym} -112 29165 0 0 {name=l1548_1 lab=n_0881}
N -92 29185 -112 29185 {lab=n_0882}
C {./lab_pin.sym} -112 29185 0 0 {name=l1548_2 lab=n_0882}
N -92 29205 -112 29205 {lab=VDD}
C {./lab_pin.sym} -112 29205 0 0 {name=l1548_3 lab=VDD}
N 92 29155 112 29155 {lab=VDD}
C {./lab_pin.sym} 112 29155 0 1 {name=l1548_4 lab=VDD}
N 92 29175 112 29175 {lab=VSS}
C {./lab_pin.sym} 112 29175 0 1 {name=l1548_5 lab=VSS}
N 92 29195 112 29195 {lab=VSS}
C {./lab_pin.sym} 112 29195 0 1 {name=l1548_6 lab=VSS}
C {./nand2_1.sym} 405 29175 0 0 {name=Xn_1490}
N 313 29145 293 29145 {lab=n_0877}
C {./lab_pin.sym} 293 29145 0 0 {name=l1549_0 lab=n_0877}
N 313 29165 293 29165 {lab=n_0881}
C {./lab_pin.sym} 293 29165 0 0 {name=l1549_1 lab=n_0881}
N 313 29185 293 29185 {lab=n_0883}
C {./lab_pin.sym} 293 29185 0 0 {name=l1549_2 lab=n_0883}
N 313 29205 293 29205 {lab=VDD}
C {./lab_pin.sym} 293 29205 0 0 {name=l1549_3 lab=VDD}
N 497 29155 517 29155 {lab=VDD}
C {./lab_pin.sym} 517 29155 0 1 {name=l1549_4 lab=VDD}
N 497 29175 517 29175 {lab=VSS}
C {./lab_pin.sym} 517 29175 0 1 {name=l1549_5 lab=VSS}
N 497 29195 517 29195 {lab=VSS}
C {./lab_pin.sym} 517 29195 0 1 {name=l1549_6 lab=VSS}
C {./aoi21_1.sym} 810 29175 0 0 {name=Xn_1491}
N 718 29145 698 29145 {lab=n_0872}
C {./lab_pin.sym} 698 29145 0 0 {name=l1550_0 lab=n_0872}
N 718 29165 698 29165 {lab=n_0879}
C {./lab_pin.sym} 698 29165 0 0 {name=l1550_1 lab=n_0879}
N 718 29185 698 29185 {lab=n_0883}
C {./lab_pin.sym} 698 29185 0 0 {name=l1550_2 lab=n_0883}
N 718 29205 698 29205 {lab=n_0884}
C {./lab_pin.sym} 698 29205 0 0 {name=l1550_3 lab=n_0884}
N 902 29145 922 29145 {lab=VDD}
C {./lab_pin.sym} 922 29145 0 1 {name=l1550_4 lab=VDD}
N 902 29165 922 29165 {lab=VDD}
C {./lab_pin.sym} 922 29165 0 1 {name=l1550_5 lab=VDD}
N 902 29185 922 29185 {lab=VSS}
C {./lab_pin.sym} 922 29185 0 1 {name=l1550_6 lab=VSS}
N 902 29205 922 29205 {lab=VSS}
C {./lab_pin.sym} 922 29205 0 1 {name=l1550_7 lab=VSS}
C {./nand2_1.sym} 1215 29175 0 0 {name=Xn_1492}
N 1123 29145 1103 29145 {lab=n_0880}
C {./lab_pin.sym} 1103 29145 0 0 {name=l1551_0 lab=n_0880}
N 1123 29165 1103 29165 {lab=n_0882}
C {./lab_pin.sym} 1103 29165 0 0 {name=l1551_1 lab=n_0882}
N 1123 29185 1103 29185 {lab=n_0885}
C {./lab_pin.sym} 1103 29185 0 0 {name=l1551_2 lab=n_0885}
N 1123 29205 1103 29205 {lab=VDD}
C {./lab_pin.sym} 1103 29205 0 0 {name=l1551_3 lab=VDD}
N 1307 29155 1327 29155 {lab=VDD}
C {./lab_pin.sym} 1327 29155 0 1 {name=l1551_4 lab=VDD}
N 1307 29175 1327 29175 {lab=VSS}
C {./lab_pin.sym} 1327 29175 0 1 {name=l1551_5 lab=VSS}
N 1307 29195 1327 29195 {lab=VSS}
C {./lab_pin.sym} 1327 29195 0 1 {name=l1551_6 lab=VSS}
C {./nor2_1.sym} 1620 29175 0 0 {name=Xn_1493}
N 1528 29145 1508 29145 {lab=u_cas_int_out_int2_b22}
C {./lab_pin.sym} 1508 29145 0 0 {name=l1552_0 lab=u_cas_int_out_int2_b22}
N 1528 29165 1508 29165 {lab=u_cas_int_out_int1_b22}
C {./lab_pin.sym} 1508 29165 0 0 {name=l1552_1 lab=u_cas_int_out_int1_b22}
N 1528 29185 1508 29185 {lab=n_0886}
C {./lab_pin.sym} 1508 29185 0 0 {name=l1552_2 lab=n_0886}
N 1528 29205 1508 29205 {lab=VDD}
C {./lab_pin.sym} 1508 29205 0 0 {name=l1552_3 lab=VDD}
N 1712 29155 1732 29155 {lab=VDD}
C {./lab_pin.sym} 1732 29155 0 1 {name=l1552_4 lab=VDD}
N 1712 29175 1732 29175 {lab=VSS}
C {./lab_pin.sym} 1732 29175 0 1 {name=l1552_5 lab=VSS}
N 1712 29195 1732 29195 {lab=VSS}
C {./lab_pin.sym} 1732 29195 0 1 {name=l1552_6 lab=VSS}
C {./and2_1.sym} 2025 29175 0 0 {name=Xn_1494}
N 1933 29145 1913 29145 {lab=u_cas_int_out_int2_b22}
C {./lab_pin.sym} 1913 29145 0 0 {name=l1553_0 lab=u_cas_int_out_int2_b22}
N 1933 29165 1913 29165 {lab=u_cas_int_out_int1_b22}
C {./lab_pin.sym} 1913 29165 0 0 {name=l1553_1 lab=u_cas_int_out_int1_b22}
N 1933 29185 1913 29185 {lab=n_0887}
C {./lab_pin.sym} 1913 29185 0 0 {name=l1553_2 lab=n_0887}
N 1933 29205 1913 29205 {lab=VDD}
C {./lab_pin.sym} 1913 29205 0 0 {name=l1553_3 lab=VDD}
N 2117 29155 2137 29155 {lab=VDD}
C {./lab_pin.sym} 2137 29155 0 1 {name=l1553_4 lab=VDD}
N 2117 29175 2137 29175 {lab=VSS}
C {./lab_pin.sym} 2137 29175 0 1 {name=l1553_5 lab=VSS}
N 2117 29195 2137 29195 {lab=VSS}
C {./lab_pin.sym} 2137 29195 0 1 {name=l1553_6 lab=VSS}
C {./nand2_1.sym} 2430 29175 0 0 {name=Xn_1495}
N 2338 29145 2318 29145 {lab=u_cas_int_out_int2_b22}
C {./lab_pin.sym} 2318 29145 0 0 {name=l1554_0 lab=u_cas_int_out_int2_b22}
N 2338 29165 2318 29165 {lab=u_cas_int_out_int1_b22}
C {./lab_pin.sym} 2318 29165 0 0 {name=l1554_1 lab=u_cas_int_out_int1_b22}
N 2338 29185 2318 29185 {lab=n_0888}
C {./lab_pin.sym} 2318 29185 0 0 {name=l1554_2 lab=n_0888}
N 2338 29205 2318 29205 {lab=VDD}
C {./lab_pin.sym} 2318 29205 0 0 {name=l1554_3 lab=VDD}
N 2522 29155 2542 29155 {lab=VDD}
C {./lab_pin.sym} 2542 29155 0 1 {name=l1554_4 lab=VDD}
N 2522 29175 2542 29175 {lab=VSS}
C {./lab_pin.sym} 2542 29175 0 1 {name=l1554_5 lab=VSS}
N 2522 29195 2542 29195 {lab=VSS}
C {./lab_pin.sym} 2542 29195 0 1 {name=l1554_6 lab=VSS}
C {./xor3_1.sym} 2835 29175 0 0 {name=Xn_1496}
N 2743 29145 2723 29145 {lab=u_cas_int_out_int2_b22}
C {./lab_pin.sym} 2723 29145 0 0 {name=l1555_0 lab=u_cas_int_out_int2_b22}
N 2743 29165 2723 29165 {lab=u_cas_int_out_int1_b22}
C {./lab_pin.sym} 2723 29165 0 0 {name=l1555_1 lab=u_cas_int_out_int1_b22}
N 2743 29185 2723 29185 {lab=n_0885}
C {./lab_pin.sym} 2723 29185 0 0 {name=l1555_2 lab=n_0885}
N 2743 29205 2723 29205 {lab=n_0101}
C {./lab_pin.sym} 2723 29205 0 0 {name=l1555_3 lab=n_0101}
N 2927 29145 2947 29145 {lab=VDD}
C {./lab_pin.sym} 2947 29145 0 1 {name=l1555_4 lab=VDD}
N 2927 29165 2947 29165 {lab=VDD}
C {./lab_pin.sym} 2947 29165 0 1 {name=l1555_5 lab=VDD}
N 2927 29185 2947 29185 {lab=VSS}
C {./lab_pin.sym} 2947 29185 0 1 {name=l1555_6 lab=VSS}
N 2927 29205 2947 29205 {lab=VSS}
C {./lab_pin.sym} 2947 29205 0 1 {name=l1555_7 lab=VSS}
C {./or2_1.sym} 3240 29175 0 0 {name=Xn_1497}
N 3148 29145 3128 29145 {lab=u_cas_int_out_int2_b23}
C {./lab_pin.sym} 3128 29145 0 0 {name=l1556_0 lab=u_cas_int_out_int2_b23}
N 3148 29165 3128 29165 {lab=u_cas_int_out_int1_b23}
C {./lab_pin.sym} 3128 29165 0 0 {name=l1556_1 lab=u_cas_int_out_int1_b23}
N 3148 29185 3128 29185 {lab=n_0889}
C {./lab_pin.sym} 3128 29185 0 0 {name=l1556_2 lab=n_0889}
N 3148 29205 3128 29205 {lab=VDD}
C {./lab_pin.sym} 3128 29205 0 0 {name=l1556_3 lab=VDD}
N 3332 29155 3352 29155 {lab=VDD}
C {./lab_pin.sym} 3352 29155 0 1 {name=l1556_4 lab=VDD}
N 3332 29175 3352 29175 {lab=VSS}
C {./lab_pin.sym} 3352 29175 0 1 {name=l1556_5 lab=VSS}
N 3332 29195 3352 29195 {lab=VSS}
C {./lab_pin.sym} 3352 29195 0 1 {name=l1556_6 lab=VSS}
C {./nand2_1.sym} 3645 29175 0 0 {name=Xn_1498}
N 3553 29145 3533 29145 {lab=u_cas_int_out_int2_b23}
C {./lab_pin.sym} 3533 29145 0 0 {name=l1557_0 lab=u_cas_int_out_int2_b23}
N 3553 29165 3533 29165 {lab=u_cas_int_out_int1_b23}
C {./lab_pin.sym} 3533 29165 0 0 {name=l1557_1 lab=u_cas_int_out_int1_b23}
N 3553 29185 3533 29185 {lab=n_0890}
C {./lab_pin.sym} 3533 29185 0 0 {name=l1557_2 lab=n_0890}
N 3553 29205 3533 29205 {lab=VDD}
C {./lab_pin.sym} 3533 29205 0 0 {name=l1557_3 lab=VDD}
N 3737 29155 3757 29155 {lab=VDD}
C {./lab_pin.sym} 3757 29155 0 1 {name=l1557_4 lab=VDD}
N 3737 29175 3757 29175 {lab=VSS}
C {./lab_pin.sym} 3757 29175 0 1 {name=l1557_5 lab=VSS}
N 3737 29195 3757 29195 {lab=VSS}
C {./lab_pin.sym} 3757 29195 0 1 {name=l1557_6 lab=VSS}
C {./and2_1.sym} 4050 29175 0 0 {name=Xn_1499}
N 3958 29145 3938 29145 {lab=n_0889}
C {./lab_pin.sym} 3938 29145 0 0 {name=l1558_0 lab=n_0889}
N 3958 29165 3938 29165 {lab=n_0890}
C {./lab_pin.sym} 3938 29165 0 0 {name=l1558_1 lab=n_0890}
N 3958 29185 3938 29185 {lab=n_0891}
C {./lab_pin.sym} 3938 29185 0 0 {name=l1558_2 lab=n_0891}
N 3958 29205 3938 29205 {lab=VDD}
C {./lab_pin.sym} 3938 29205 0 0 {name=l1558_3 lab=VDD}
N 4142 29155 4162 29155 {lab=VDD}
C {./lab_pin.sym} 4162 29155 0 1 {name=l1558_4 lab=VDD}
N 4142 29175 4162 29175 {lab=VSS}
C {./lab_pin.sym} 4162 29175 0 1 {name=l1558_5 lab=VSS}
N 4142 29195 4162 29195 {lab=VSS}
C {./lab_pin.sym} 4162 29195 0 1 {name=l1558_6 lab=VSS}
C {./nand2_1.sym} 4455 29175 0 0 {name=Xn_1500}
N 4363 29145 4343 29145 {lab=n_0889}
C {./lab_pin.sym} 4343 29145 0 0 {name=l1559_0 lab=n_0889}
N 4363 29165 4343 29165 {lab=n_0890}
C {./lab_pin.sym} 4343 29165 0 0 {name=l1559_1 lab=n_0890}
N 4363 29185 4343 29185 {lab=n_0892}
C {./lab_pin.sym} 4343 29185 0 0 {name=l1559_2 lab=n_0892}
N 4363 29205 4343 29205 {lab=VDD}
C {./lab_pin.sym} 4343 29205 0 0 {name=l1559_3 lab=VDD}
N 4547 29155 4567 29155 {lab=VDD}
C {./lab_pin.sym} 4567 29155 0 1 {name=l1559_4 lab=VDD}
N 4547 29175 4567 29175 {lab=VSS}
C {./lab_pin.sym} 4567 29175 0 1 {name=l1559_5 lab=VSS}
N 4547 29195 4567 29195 {lab=VSS}
C {./lab_pin.sym} 4567 29195 0 1 {name=l1559_6 lab=VSS}
C {./aoi21_1.sym} 0 29400 0 0 {name=Xn_1501}
N -92 29370 -112 29370 {lab=n_0880}
C {./lab_pin.sym} -112 29370 0 0 {name=l1560_0 lab=n_0880}
N -92 29390 -112 29390 {lab=n_0882}
C {./lab_pin.sym} -112 29390 0 0 {name=l1560_1 lab=n_0882}
N -92 29410 -112 29410 {lab=n_0886}
C {./lab_pin.sym} -112 29410 0 0 {name=l1560_2 lab=n_0886}
N -92 29430 -112 29430 {lab=n_0893}
C {./lab_pin.sym} -112 29430 0 0 {name=l1560_3 lab=n_0893}
N 92 29370 112 29370 {lab=VDD}
C {./lab_pin.sym} 112 29370 0 1 {name=l1560_4 lab=VDD}
N 92 29390 112 29390 {lab=VDD}
C {./lab_pin.sym} 112 29390 0 1 {name=l1560_5 lab=VDD}
N 92 29410 112 29410 {lab=VSS}
C {./lab_pin.sym} 112 29410 0 1 {name=l1560_6 lab=VSS}
N 92 29430 112 29430 {lab=VSS}
C {./lab_pin.sym} 112 29430 0 1 {name=l1560_7 lab=VSS}
C {./oai21_1.sym} 405 29400 0 0 {name=Xn_1502}
N 313 29370 293 29370 {lab=n_0887}
C {./lab_pin.sym} 293 29370 0 0 {name=l1561_0 lab=n_0887}
N 313 29390 293 29390 {lab=n_0893}
C {./lab_pin.sym} 293 29390 0 0 {name=l1561_1 lab=n_0893}
N 313 29410 293 29410 {lab=n_0892}
C {./lab_pin.sym} 293 29410 0 0 {name=l1561_2 lab=n_0892}
N 313 29430 293 29430 {lab=n_0894}
C {./lab_pin.sym} 293 29430 0 0 {name=l1561_3 lab=n_0894}
N 497 29370 517 29370 {lab=VDD}
C {./lab_pin.sym} 517 29370 0 1 {name=l1561_4 lab=VDD}
N 497 29390 517 29390 {lab=VDD}
C {./lab_pin.sym} 517 29390 0 1 {name=l1561_5 lab=VDD}
N 497 29410 517 29410 {lab=VSS}
C {./lab_pin.sym} 517 29410 0 1 {name=l1561_6 lab=VSS}
N 497 29430 517 29430 {lab=VSS}
C {./lab_pin.sym} 517 29430 0 1 {name=l1561_7 lab=VSS}
C {./oai211_1.sym} 810 29400 0 0 {name=Xn_1503}
N 718 29360 698 29360 {lab=n_0884}
C {./lab_pin.sym} 698 29360 0 0 {name=l1562_0 lab=n_0884}
N 718 29380 698 29380 {lab=n_0886}
C {./lab_pin.sym} 698 29380 0 0 {name=l1562_1 lab=n_0886}
N 718 29400 698 29400 {lab=n_0888}
C {./lab_pin.sym} 698 29400 0 0 {name=l1562_2 lab=n_0888}
N 718 29420 698 29420 {lab=n_0891}
C {./lab_pin.sym} 698 29420 0 0 {name=l1562_3 lab=n_0891}
N 718 29440 698 29440 {lab=n_0895}
C {./lab_pin.sym} 698 29440 0 0 {name=l1562_4 lab=n_0895}
N 902 29370 922 29370 {lab=VDD}
C {./lab_pin.sym} 922 29370 0 1 {name=l1562_5 lab=VDD}
N 902 29390 922 29390 {lab=VDD}
C {./lab_pin.sym} 922 29390 0 1 {name=l1562_6 lab=VDD}
N 902 29410 922 29410 {lab=VSS}
C {./lab_pin.sym} 922 29410 0 1 {name=l1562_7 lab=VSS}
N 902 29430 922 29430 {lab=VSS}
C {./lab_pin.sym} 922 29430 0 1 {name=l1562_8 lab=VSS}
C {./nand2_1.sym} 1215 29400 0 0 {name=Xn_1504}
N 1123 29370 1103 29370 {lab=n_0894}
C {./lab_pin.sym} 1103 29370 0 0 {name=l1563_0 lab=n_0894}
N 1123 29390 1103 29390 {lab=n_0895}
C {./lab_pin.sym} 1103 29390 0 0 {name=l1563_1 lab=n_0895}
N 1123 29410 1103 29410 {lab=n_0102}
C {./lab_pin.sym} 1103 29410 0 0 {name=l1563_2 lab=n_0102}
N 1123 29430 1103 29430 {lab=VDD}
C {./lab_pin.sym} 1103 29430 0 0 {name=l1563_3 lab=VDD}
N 1307 29380 1327 29380 {lab=VDD}
C {./lab_pin.sym} 1327 29380 0 1 {name=l1563_4 lab=VDD}
N 1307 29400 1327 29400 {lab=VSS}
C {./lab_pin.sym} 1327 29400 0 1 {name=l1563_5 lab=VSS}
N 1307 29420 1327 29420 {lab=VSS}
C {./lab_pin.sym} 1327 29420 0 1 {name=l1563_6 lab=VSS}
C {./nor3_1.sym} 1620 29400 0 0 {name=Xn_1505}
N 1528 29370 1508 29370 {lab=n_0892}
C {./lab_pin.sym} 1508 29370 0 0 {name=l1564_0 lab=n_0892}
N 1528 29390 1508 29390 {lab=n_0887}
C {./lab_pin.sym} 1508 29390 0 0 {name=l1564_1 lab=n_0887}
N 1528 29410 1508 29410 {lab=n_0886}
C {./lab_pin.sym} 1508 29410 0 0 {name=l1564_2 lab=n_0886}
N 1528 29430 1508 29430 {lab=n_0896}
C {./lab_pin.sym} 1508 29430 0 0 {name=l1564_3 lab=n_0896}
N 1712 29370 1732 29370 {lab=VDD}
C {./lab_pin.sym} 1732 29370 0 1 {name=l1564_4 lab=VDD}
N 1712 29390 1732 29390 {lab=VDD}
C {./lab_pin.sym} 1732 29390 0 1 {name=l1564_5 lab=VDD}
N 1712 29410 1732 29410 {lab=VSS}
C {./lab_pin.sym} 1732 29410 0 1 {name=l1564_6 lab=VSS}
N 1712 29430 1732 29430 {lab=VSS}
C {./lab_pin.sym} 1732 29430 0 1 {name=l1564_7 lab=VSS}
C {./clkinv_1.sym} 2025 29400 0 0 {name=Xn_1506}
N 1933 29380 1913 29380 {lab=n_0896}
C {./lab_pin.sym} 1913 29380 0 0 {name=l1565_0 lab=n_0896}
N 1933 29400 1913 29400 {lab=n_0897}
C {./lab_pin.sym} 1913 29400 0 0 {name=l1565_1 lab=n_0897}
N 1933 29420 1913 29420 {lab=VDD}
C {./lab_pin.sym} 1913 29420 0 0 {name=l1565_2 lab=VDD}
N 2117 29380 2137 29380 {lab=VDD}
C {./lab_pin.sym} 2137 29380 0 1 {name=l1565_3 lab=VDD}
N 2117 29400 2137 29400 {lab=VSS}
C {./lab_pin.sym} 2137 29400 0 1 {name=l1565_4 lab=VSS}
N 2117 29420 2137 29420 {lab=VSS}
C {./lab_pin.sym} 2137 29420 0 1 {name=l1565_5 lab=VSS}
C {./aoi21_1.sym} 2430 29400 0 0 {name=Xn_1507}
N 2338 29370 2318 29370 {lab=n_0880}
C {./lab_pin.sym} 2318 29370 0 0 {name=l1566_0 lab=n_0880}
N 2338 29390 2318 29390 {lab=n_0882}
C {./lab_pin.sym} 2318 29390 0 0 {name=l1566_1 lab=n_0882}
N 2338 29410 2318 29410 {lab=n_0897}
C {./lab_pin.sym} 2318 29410 0 0 {name=l1566_2 lab=n_0897}
N 2338 29430 2318 29430 {lab=n_0898}
C {./lab_pin.sym} 2318 29430 0 0 {name=l1566_3 lab=n_0898}
N 2522 29370 2542 29370 {lab=VDD}
C {./lab_pin.sym} 2542 29370 0 1 {name=l1566_4 lab=VDD}
N 2522 29390 2542 29390 {lab=VDD}
C {./lab_pin.sym} 2542 29390 0 1 {name=l1566_5 lab=VDD}
N 2522 29410 2542 29410 {lab=VSS}
C {./lab_pin.sym} 2542 29410 0 1 {name=l1566_6 lab=VSS}
N 2522 29430 2542 29430 {lab=VSS}
C {./lab_pin.sym} 2542 29430 0 1 {name=l1566_7 lab=VSS}
C {./nand3_1.sym} 2835 29400 0 0 {name=Xn_1508}
N 2743 29370 2723 29370 {lab=n_0889}
C {./lab_pin.sym} 2723 29370 0 0 {name=l1567_0 lab=n_0889}
N 2743 29390 2723 29390 {lab=u_cas_int_out_int1_b22}
C {./lab_pin.sym} 2723 29390 0 0 {name=l1567_1 lab=u_cas_int_out_int1_b22}
N 2743 29410 2723 29410 {lab=u_cas_int_out_int2_b22}
C {./lab_pin.sym} 2723 29410 0 0 {name=l1567_2 lab=u_cas_int_out_int2_b22}
N 2743 29430 2723 29430 {lab=n_0899}
C {./lab_pin.sym} 2723 29430 0 0 {name=l1567_3 lab=n_0899}
N 2927 29370 2947 29370 {lab=VDD}
C {./lab_pin.sym} 2947 29370 0 1 {name=l1567_4 lab=VDD}
N 2927 29390 2947 29390 {lab=VDD}
C {./lab_pin.sym} 2947 29390 0 1 {name=l1567_5 lab=VDD}
N 2927 29410 2947 29410 {lab=VSS}
C {./lab_pin.sym} 2947 29410 0 1 {name=l1567_6 lab=VSS}
N 2927 29430 2947 29430 {lab=VSS}
C {./lab_pin.sym} 2947 29430 0 1 {name=l1567_7 lab=VSS}
C {./and2_1.sym} 3240 29400 0 0 {name=Xn_1509}
N 3148 29370 3128 29370 {lab=n_0890}
C {./lab_pin.sym} 3128 29370 0 0 {name=l1568_0 lab=n_0890}
N 3148 29390 3128 29390 {lab=n_0899}
C {./lab_pin.sym} 3128 29390 0 0 {name=l1568_1 lab=n_0899}
N 3148 29410 3128 29410 {lab=n_0900}
C {./lab_pin.sym} 3128 29410 0 0 {name=l1568_2 lab=n_0900}
N 3148 29430 3128 29430 {lab=VDD}
C {./lab_pin.sym} 3128 29430 0 0 {name=l1568_3 lab=VDD}
N 3332 29380 3352 29380 {lab=VDD}
C {./lab_pin.sym} 3352 29380 0 1 {name=l1568_4 lab=VDD}
N 3332 29400 3352 29400 {lab=VSS}
C {./lab_pin.sym} 3352 29400 0 1 {name=l1568_5 lab=VSS}
N 3332 29420 3352 29420 {lab=VSS}
C {./lab_pin.sym} 3352 29420 0 1 {name=l1568_6 lab=VSS}
C {./nand2_1.sym} 3645 29400 0 0 {name=Xn_1510}
N 3553 29370 3533 29370 {lab=n_0890}
C {./lab_pin.sym} 3533 29370 0 0 {name=l1569_0 lab=n_0890}
N 3553 29390 3533 29390 {lab=n_0899}
C {./lab_pin.sym} 3533 29390 0 0 {name=l1569_1 lab=n_0899}
N 3553 29410 3533 29410 {lab=n_0901}
C {./lab_pin.sym} 3533 29410 0 0 {name=l1569_2 lab=n_0901}
N 3553 29430 3533 29430 {lab=VDD}
C {./lab_pin.sym} 3533 29430 0 0 {name=l1569_3 lab=VDD}
N 3737 29380 3757 29380 {lab=VDD}
C {./lab_pin.sym} 3757 29380 0 1 {name=l1569_4 lab=VDD}
N 3737 29400 3757 29400 {lab=VSS}
C {./lab_pin.sym} 3757 29400 0 1 {name=l1569_5 lab=VSS}
N 3737 29420 3757 29420 {lab=VSS}
C {./lab_pin.sym} 3757 29420 0 1 {name=l1569_6 lab=VSS}
C {./xnor2_1.sym} 4050 29400 0 0 {name=Xn_1511}
N 3958 29370 3938 29370 {lab=u_cas_int_out_int2_b24}
C {./lab_pin.sym} 3938 29370 0 0 {name=l1570_0 lab=u_cas_int_out_int2_b24}
N 3958 29390 3938 29390 {lab=u_cas_int_out_int1_b24}
C {./lab_pin.sym} 3938 29390 0 0 {name=l1570_1 lab=u_cas_int_out_int1_b24}
N 3958 29410 3938 29410 {lab=n_0902}
C {./lab_pin.sym} 3938 29410 0 0 {name=l1570_2 lab=n_0902}
N 3958 29430 3938 29430 {lab=VDD}
C {./lab_pin.sym} 3938 29430 0 0 {name=l1570_3 lab=VDD}
N 4142 29380 4162 29380 {lab=VDD}
C {./lab_pin.sym} 4162 29380 0 1 {name=l1570_4 lab=VDD}
N 4142 29400 4162 29400 {lab=VSS}
C {./lab_pin.sym} 4162 29400 0 1 {name=l1570_5 lab=VSS}
N 4142 29420 4162 29420 {lab=VSS}
C {./lab_pin.sym} 4162 29420 0 1 {name=l1570_6 lab=VSS}
C {./xor2_1.sym} 4455 29400 0 0 {name=Xn_1512}
N 4363 29370 4343 29370 {lab=u_cas_int_out_int2_b24}
C {./lab_pin.sym} 4343 29370 0 0 {name=l1571_0 lab=u_cas_int_out_int2_b24}
N 4363 29390 4343 29390 {lab=u_cas_int_out_int1_b24}
C {./lab_pin.sym} 4343 29390 0 0 {name=l1571_1 lab=u_cas_int_out_int1_b24}
N 4363 29410 4343 29410 {lab=n_0903}
C {./lab_pin.sym} 4343 29410 0 0 {name=l1571_2 lab=n_0903}
N 4363 29430 4343 29430 {lab=VDD}
C {./lab_pin.sym} 4343 29430 0 0 {name=l1571_3 lab=VDD}
N 4547 29380 4567 29380 {lab=VDD}
C {./lab_pin.sym} 4567 29380 0 1 {name=l1571_4 lab=VDD}
N 4547 29400 4567 29400 {lab=VSS}
C {./lab_pin.sym} 4567 29400 0 1 {name=l1571_5 lab=VSS}
N 4547 29420 4567 29420 {lab=VSS}
C {./lab_pin.sym} 4567 29420 0 1 {name=l1571_6 lab=VSS}
C {./oai211_1.sym} 0 29625 0 0 {name=Xn_1513}
N -92 29585 -112 29585 {lab=n_0884}
C {./lab_pin.sym} -112 29585 0 0 {name=l1572_0 lab=n_0884}
N -92 29605 -112 29605 {lab=n_0897}
C {./lab_pin.sym} -112 29605 0 0 {name=l1572_1 lab=n_0897}
N -92 29625 -112 29625 {lab=n_0900}
C {./lab_pin.sym} -112 29625 0 0 {name=l1572_2 lab=n_0900}
N -92 29645 -112 29645 {lab=n_0903}
C {./lab_pin.sym} -112 29645 0 0 {name=l1572_3 lab=n_0903}
N -92 29665 -112 29665 {lab=n_0904}
C {./lab_pin.sym} -112 29665 0 0 {name=l1572_4 lab=n_0904}
N 92 29595 112 29595 {lab=VDD}
C {./lab_pin.sym} 112 29595 0 1 {name=l1572_5 lab=VDD}
N 92 29615 112 29615 {lab=VDD}
C {./lab_pin.sym} 112 29615 0 1 {name=l1572_6 lab=VDD}
N 92 29635 112 29635 {lab=VSS}
C {./lab_pin.sym} 112 29635 0 1 {name=l1572_7 lab=VSS}
N 92 29655 112 29655 {lab=VSS}
C {./lab_pin.sym} 112 29655 0 1 {name=l1572_8 lab=VSS}
C {./oai21_1.sym} 405 29625 0 0 {name=Xn_1514}
N 313 29595 293 29595 {lab=n_0898}
C {./lab_pin.sym} 293 29595 0 0 {name=l1573_0 lab=n_0898}
N 313 29615 293 29615 {lab=n_0901}
C {./lab_pin.sym} 293 29615 0 0 {name=l1573_1 lab=n_0901}
N 313 29635 293 29635 {lab=n_0902}
C {./lab_pin.sym} 293 29635 0 0 {name=l1573_2 lab=n_0902}
N 313 29655 293 29655 {lab=n_0905}
C {./lab_pin.sym} 293 29655 0 0 {name=l1573_3 lab=n_0905}
N 497 29595 517 29595 {lab=VDD}
C {./lab_pin.sym} 517 29595 0 1 {name=l1573_4 lab=VDD}
N 497 29615 517 29615 {lab=VDD}
C {./lab_pin.sym} 517 29615 0 1 {name=l1573_5 lab=VDD}
N 497 29635 517 29635 {lab=VSS}
C {./lab_pin.sym} 517 29635 0 1 {name=l1573_6 lab=VSS}
N 497 29655 517 29655 {lab=VSS}
C {./lab_pin.sym} 517 29655 0 1 {name=l1573_7 lab=VSS}
C {./nand2_1.sym} 810 29625 0 0 {name=Xn_1515}
N 718 29595 698 29595 {lab=n_0904}
C {./lab_pin.sym} 698 29595 0 0 {name=l1574_0 lab=n_0904}
N 718 29615 698 29615 {lab=n_0905}
C {./lab_pin.sym} 698 29615 0 0 {name=l1574_1 lab=n_0905}
N 718 29635 698 29635 {lab=n_0103}
C {./lab_pin.sym} 698 29635 0 0 {name=l1574_2 lab=n_0103}
N 718 29655 698 29655 {lab=VDD}
C {./lab_pin.sym} 698 29655 0 0 {name=l1574_3 lab=VDD}
N 902 29605 922 29605 {lab=VDD}
C {./lab_pin.sym} 922 29605 0 1 {name=l1574_4 lab=VDD}
N 902 29625 922 29625 {lab=VSS}
C {./lab_pin.sym} 922 29625 0 1 {name=l1574_5 lab=VSS}
N 902 29645 922 29645 {lab=VSS}
C {./lab_pin.sym} 922 29645 0 1 {name=l1574_6 lab=VSS}
C {./nand2_1.sym} 1215 29625 0 0 {name=Xn_1516}
N 1123 29595 1103 29595 {lab=u_cas_int_out_int1_b0}
C {./lab_pin.sym} 1103 29595 0 0 {name=l1575_0 lab=u_cas_int_out_int1_b0}
N 1123 29615 1103 29615 {lab=net1}
C {./lab_pin.sym} 1103 29615 0 0 {name=l1575_1 lab=net1}
N 1123 29635 1103 29635 {lab=n_0906}
C {./lab_pin.sym} 1103 29635 0 0 {name=l1575_2 lab=n_0906}
N 1123 29655 1103 29655 {lab=VDD}
C {./lab_pin.sym} 1103 29655 0 0 {name=l1575_3 lab=VDD}
N 1307 29605 1327 29605 {lab=VDD}
C {./lab_pin.sym} 1327 29605 0 1 {name=l1575_4 lab=VDD}
N 1307 29625 1327 29625 {lab=VSS}
C {./lab_pin.sym} 1327 29625 0 1 {name=l1575_5 lab=VSS}
N 1307 29645 1327 29645 {lab=VSS}
C {./lab_pin.sym} 1327 29645 0 1 {name=l1575_6 lab=VSS}
C {./nand3_1.sym} 1620 29625 0 0 {name=Xn_1517}
N 1528 29595 1508 29595 {lab=u_cas_int_out_int1_b1}
C {./lab_pin.sym} 1508 29595 0 0 {name=l1576_0 lab=u_cas_int_out_int1_b1}
N 1528 29615 1508 29615 {lab=u_cas_int_out_int1_b0}
C {./lab_pin.sym} 1508 29615 0 0 {name=l1576_1 lab=u_cas_int_out_int1_b0}
N 1528 29635 1508 29635 {lab=net1}
C {./lab_pin.sym} 1508 29635 0 0 {name=l1576_2 lab=net1}
N 1528 29655 1508 29655 {lab=n_0907}
C {./lab_pin.sym} 1508 29655 0 0 {name=l1576_3 lab=n_0907}
N 1712 29595 1732 29595 {lab=VDD}
C {./lab_pin.sym} 1732 29595 0 1 {name=l1576_4 lab=VDD}
N 1712 29615 1732 29615 {lab=VDD}
C {./lab_pin.sym} 1732 29615 0 1 {name=l1576_5 lab=VDD}
N 1712 29635 1732 29635 {lab=VSS}
C {./lab_pin.sym} 1732 29635 0 1 {name=l1576_6 lab=VSS}
N 1712 29655 1732 29655 {lab=VSS}
C {./lab_pin.sym} 1732 29655 0 1 {name=l1576_7 lab=VSS}
C {./xnor2_1.sym} 2025 29625 0 0 {name=Xn_1518}
N 1933 29595 1913 29595 {lab=u_cas_int_out_int1_b1}
C {./lab_pin.sym} 1913 29595 0 0 {name=l1577_0 lab=u_cas_int_out_int1_b1}
N 1933 29615 1913 29615 {lab=n_0906}
C {./lab_pin.sym} 1913 29615 0 0 {name=l1577_1 lab=n_0906}
N 1933 29635 1913 29635 {lab=n_0073}
C {./lab_pin.sym} 1913 29635 0 0 {name=l1577_2 lab=n_0073}
N 1933 29655 1913 29655 {lab=VDD}
C {./lab_pin.sym} 1913 29655 0 0 {name=l1577_3 lab=VDD}
N 2117 29605 2137 29605 {lab=VDD}
C {./lab_pin.sym} 2137 29605 0 1 {name=l1577_4 lab=VDD}
N 2117 29625 2137 29625 {lab=VSS}
C {./lab_pin.sym} 2137 29625 0 1 {name=l1577_5 lab=VSS}
N 2117 29645 2137 29645 {lab=VSS}
C {./lab_pin.sym} 2137 29645 0 1 {name=l1577_6 lab=VSS}
C {./and4_1.sym} 2430 29625 0 0 {name=Xn_1519}
N 2338 29585 2318 29585 {lab=u_cas_int_out_int1_b1}
C {./lab_pin.sym} 2318 29585 0 0 {name=l1578_0 lab=u_cas_int_out_int1_b1}
N 2338 29605 2318 29605 {lab=u_cas_int_out_int1_b0}
C {./lab_pin.sym} 2318 29605 0 0 {name=l1578_1 lab=u_cas_int_out_int1_b0}
N 2338 29625 2318 29625 {lab=u_cas_int_out_int1_b2}
C {./lab_pin.sym} 2318 29625 0 0 {name=l1578_2 lab=u_cas_int_out_int1_b2}
N 2338 29645 2318 29645 {lab=net1}
C {./lab_pin.sym} 2318 29645 0 0 {name=l1578_3 lab=net1}
N 2338 29665 2318 29665 {lab=n_0908}
C {./lab_pin.sym} 2318 29665 0 0 {name=l1578_4 lab=n_0908}
N 2522 29595 2542 29595 {lab=VDD}
C {./lab_pin.sym} 2542 29595 0 1 {name=l1578_5 lab=VDD}
N 2522 29615 2542 29615 {lab=VDD}
C {./lab_pin.sym} 2542 29615 0 1 {name=l1578_6 lab=VDD}
N 2522 29635 2542 29635 {lab=VSS}
C {./lab_pin.sym} 2542 29635 0 1 {name=l1578_7 lab=VSS}
N 2522 29655 2542 29655 {lab=VSS}
C {./lab_pin.sym} 2542 29655 0 1 {name=l1578_8 lab=VSS}
C {./xnor2_1.sym} 2835 29625 0 0 {name=Xn_1520}
N 2743 29595 2723 29595 {lab=u_cas_int_out_int1_b2}
C {./lab_pin.sym} 2723 29595 0 0 {name=l1579_0 lab=u_cas_int_out_int1_b2}
N 2743 29615 2723 29615 {lab=n_0907}
C {./lab_pin.sym} 2723 29615 0 0 {name=l1579_1 lab=n_0907}
N 2743 29635 2723 29635 {lab=n_0079}
C {./lab_pin.sym} 2723 29635 0 0 {name=l1579_2 lab=n_0079}
N 2743 29655 2723 29655 {lab=VDD}
C {./lab_pin.sym} 2723 29655 0 0 {name=l1579_3 lab=VDD}
N 2927 29605 2947 29605 {lab=VDD}
C {./lab_pin.sym} 2947 29605 0 1 {name=l1579_4 lab=VDD}
N 2927 29625 2947 29625 {lab=VSS}
C {./lab_pin.sym} 2947 29625 0 1 {name=l1579_5 lab=VSS}
N 2927 29645 2947 29645 {lab=VSS}
C {./lab_pin.sym} 2947 29645 0 1 {name=l1579_6 lab=VSS}
C {./nand2_1.sym} 3240 29625 0 0 {name=Xn_1521}
N 3148 29595 3128 29595 {lab=u_cas_int_out_int1_b3}
C {./lab_pin.sym} 3128 29595 0 0 {name=l1580_0 lab=u_cas_int_out_int1_b3}
N 3148 29615 3128 29615 {lab=n_0908}
C {./lab_pin.sym} 3128 29615 0 0 {name=l1580_1 lab=n_0908}
N 3148 29635 3128 29635 {lab=n_0909}
C {./lab_pin.sym} 3128 29635 0 0 {name=l1580_2 lab=n_0909}
N 3148 29655 3128 29655 {lab=VDD}
C {./lab_pin.sym} 3128 29655 0 0 {name=l1580_3 lab=VDD}
N 3332 29605 3352 29605 {lab=VDD}
C {./lab_pin.sym} 3352 29605 0 1 {name=l1580_4 lab=VDD}
N 3332 29625 3352 29625 {lab=VSS}
C {./lab_pin.sym} 3352 29625 0 1 {name=l1580_5 lab=VSS}
N 3332 29645 3352 29645 {lab=VSS}
