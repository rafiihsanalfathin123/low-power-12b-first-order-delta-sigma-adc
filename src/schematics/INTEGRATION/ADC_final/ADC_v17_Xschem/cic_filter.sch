C {./lab_pin.sym} 1508 39270 0 0 {name=l2092_0 lab=out_cas_int_b21}
N 1528 39290 1508 39290 {lab=n_0583}
C {./lab_pin.sym} 1508 39290 0 0 {name=l2092_1 lab=n_0583}
N 1528 39310 1508 39310 {lab=n_0450}
C {./lab_pin.sym} 1508 39310 0 0 {name=l2092_2 lab=n_0450}
N 1528 39330 1508 39330 {lab=n_0013}
C {./lab_pin.sym} 1508 39330 0 0 {name=l2092_3 lab=n_0013}
N 1712 39270 1732 39270 {lab=VDD}
C {./lab_pin.sym} 1732 39270 0 1 {name=l2092_4 lab=VDD}
N 1712 39290 1732 39290 {lab=VDD}
C {./lab_pin.sym} 1732 39290 0 1 {name=l2092_5 lab=VDD}
N 1712 39310 1732 39310 {lab=VSS}
C {./lab_pin.sym} 1732 39310 0 1 {name=l2092_6 lab=VSS}
N 1712 39330 1732 39330 {lab=VSS}
C {./lab_pin.sym} 1732 39330 0 1 {name=l2092_7 lab=VSS}
C {./nor2_1.sym} 2025 39300 0 0 {name=Xn_2034}
N 1933 39270 1913 39270 {lab=n_0495}
C {./lab_pin.sym} 1913 39270 0 0 {name=l2093_0 lab=n_0495}
N 1933 39290 1913 39290 {lab=u_cas_diff_u_diff1_in_min1_b22}
C {./lab_pin.sym} 1913 39290 0 0 {name=l2093_1 lab=u_cas_diff_u_diff1_in_min1_b22}
N 1933 39310 1913 39310 {lab=n_0453}
C {./lab_pin.sym} 1913 39310 0 0 {name=l2093_2 lab=n_0453}
N 1933 39330 1913 39330 {lab=VDD}
C {./lab_pin.sym} 1913 39330 0 0 {name=l2093_3 lab=VDD}
N 2117 39280 2137 39280 {lab=VDD}
C {./lab_pin.sym} 2137 39280 0 1 {name=l2093_4 lab=VDD}
N 2117 39300 2137 39300 {lab=VSS}
C {./lab_pin.sym} 2137 39300 0 1 {name=l2093_5 lab=VSS}
N 2117 39320 2137 39320 {lab=VSS}
C {./lab_pin.sym} 2137 39320 0 1 {name=l2093_6 lab=VSS}
C {./nand2_1.sym} 2430 39300 0 0 {name=Xn_2035}
N 2338 39270 2318 39270 {lab=n_0584}
C {./lab_pin.sym} 2318 39270 0 0 {name=l2094_0 lab=n_0584}
N 2338 39290 2318 39290 {lab=out_cas_int_b22}
C {./lab_pin.sym} 2318 39290 0 0 {name=l2094_1 lab=out_cas_int_b22}
N 2338 39310 2318 39310 {lab=n_0454}
C {./lab_pin.sym} 2318 39310 0 0 {name=l2094_2 lab=n_0454}
N 2338 39330 2318 39330 {lab=VDD}
C {./lab_pin.sym} 2318 39330 0 0 {name=l2094_3 lab=VDD}
N 2522 39280 2542 39280 {lab=VDD}
C {./lab_pin.sym} 2542 39280 0 1 {name=l2094_4 lab=VDD}
N 2522 39300 2542 39300 {lab=VSS}
C {./lab_pin.sym} 2542 39300 0 1 {name=l2094_5 lab=VSS}
N 2522 39320 2542 39320 {lab=VSS}
C {./lab_pin.sym} 2542 39320 0 1 {name=l2094_6 lab=VSS}
C {./nor2_1.sym} 2835 39300 0 0 {name=Xn_2036}
N 2743 39270 2723 39270 {lab=n_0584}
C {./lab_pin.sym} 2723 39270 0 0 {name=l2095_0 lab=n_0584}
N 2743 39290 2723 39290 {lab=out_cas_int_b22}
C {./lab_pin.sym} 2723 39290 0 0 {name=l2095_1 lab=out_cas_int_b22}
N 2743 39310 2723 39310 {lab=n_0455}
C {./lab_pin.sym} 2723 39310 0 0 {name=l2095_2 lab=n_0455}
N 2743 39330 2723 39330 {lab=VDD}
C {./lab_pin.sym} 2723 39330 0 0 {name=l2095_3 lab=VDD}
N 2927 39280 2947 39280 {lab=VDD}
C {./lab_pin.sym} 2947 39280 0 1 {name=l2095_4 lab=VDD}
N 2927 39300 2947 39300 {lab=VSS}
C {./lab_pin.sym} 2947 39300 0 1 {name=l2095_5 lab=VSS}
N 2927 39320 2947 39320 {lab=VSS}
C {./lab_pin.sym} 2947 39320 0 1 {name=l2095_6 lab=VSS}
C {./nor2_1.sym} 3240 39300 0 0 {name=Xn_2037}
N 3148 39270 3128 39270 {lab=n_0453}
C {./lab_pin.sym} 3128 39270 0 0 {name=l2096_0 lab=n_0453}
N 3148 39290 3128 39290 {lab=n_0455}
C {./lab_pin.sym} 3128 39290 0 0 {name=l2096_1 lab=n_0455}
N 3148 39310 3128 39310 {lab=n_0456}
C {./lab_pin.sym} 3128 39310 0 0 {name=l2096_2 lab=n_0456}
N 3148 39330 3128 39330 {lab=VDD}
C {./lab_pin.sym} 3128 39330 0 0 {name=l2096_3 lab=VDD}
N 3332 39280 3352 39280 {lab=VDD}
C {./lab_pin.sym} 3352 39280 0 1 {name=l2096_4 lab=VDD}
N 3332 39300 3352 39300 {lab=VSS}
C {./lab_pin.sym} 3352 39300 0 1 {name=l2096_5 lab=VSS}
N 3332 39320 3352 39320 {lab=VSS}
C {./lab_pin.sym} 3352 39320 0 1 {name=l2096_6 lab=VSS}
C {./nand4_1.sym} 3645 39300 0 0 {name=Xn_2038}
N 3553 39260 3533 39260 {lab=n_0438}
C {./lab_pin.sym} 3533 39260 0 0 {name=l2097_0 lab=n_0438}
N 3553 39280 3533 39280 {lab=n_0439}
C {./lab_pin.sym} 3533 39280 0 0 {name=l2097_1 lab=n_0439}
N 3553 39300 3533 39300 {lab=n_0451}
C {./lab_pin.sym} 3533 39300 0 0 {name=l2097_2 lab=n_0451}
N 3553 39320 3533 39320 {lab=n_0452}
C {./lab_pin.sym} 3533 39320 0 0 {name=l2097_3 lab=n_0452}
N 3553 39340 3533 39340 {lab=n_0457}
C {./lab_pin.sym} 3533 39340 0 0 {name=l2097_4 lab=n_0457}
N 3737 39270 3757 39270 {lab=VDD}
C {./lab_pin.sym} 3757 39270 0 1 {name=l2097_5 lab=VDD}
N 3737 39290 3757 39290 {lab=VDD}
C {./lab_pin.sym} 3757 39290 0 1 {name=l2097_6 lab=VDD}
N 3737 39310 3757 39310 {lab=VSS}
C {./lab_pin.sym} 3757 39310 0 1 {name=l2097_7 lab=VSS}
N 3737 39330 3757 39330 {lab=VSS}
C {./lab_pin.sym} 3757 39330 0 1 {name=l2097_8 lab=VSS}
C {./aoi21_1.sym} 4050 39300 0 0 {name=Xn_2039}
N 3958 39270 3938 39270 {lab=n_0448}
C {./lab_pin.sym} 3938 39270 0 0 {name=l2098_0 lab=n_0448}
N 3958 39290 3938 39290 {lab=n_0445}
C {./lab_pin.sym} 3938 39290 0 0 {name=l2098_1 lab=n_0445}
N 3958 39310 3938 39310 {lab=n_0457}
C {./lab_pin.sym} 3938 39310 0 0 {name=l2098_2 lab=n_0457}
N 3958 39330 3938 39330 {lab=n_0458}
C {./lab_pin.sym} 3938 39330 0 0 {name=l2098_3 lab=n_0458}
N 4142 39270 4162 39270 {lab=VDD}
C {./lab_pin.sym} 4162 39270 0 1 {name=l2098_4 lab=VDD}
N 4142 39290 4162 39290 {lab=VDD}
C {./lab_pin.sym} 4162 39290 0 1 {name=l2098_5 lab=VDD}
N 4142 39310 4162 39310 {lab=VSS}
C {./lab_pin.sym} 4162 39310 0 1 {name=l2098_6 lab=VSS}
N 4142 39330 4162 39330 {lab=VSS}
C {./lab_pin.sym} 4162 39330 0 1 {name=l2098_7 lab=VSS}
C {./nand3_1.sym} 4455 39300 0 0 {name=Xn_2040}
N 4363 39270 4343 39270 {lab=n_0452}
C {./lab_pin.sym} 4343 39270 0 0 {name=l2099_0 lab=n_0452}
N 4363 39290 4343 39290 {lab=out_cas_int_b20}
C {./lab_pin.sym} 4343 39290 0 0 {name=l2099_1 lab=out_cas_int_b20}
N 4363 39310 4343 39310 {lab=n_0582}
C {./lab_pin.sym} 4343 39310 0 0 {name=l2099_2 lab=n_0582}
N 4363 39330 4343 39330 {lab=n_0459}
C {./lab_pin.sym} 4343 39330 0 0 {name=l2099_3 lab=n_0459}
N 4547 39270 4567 39270 {lab=VDD}
C {./lab_pin.sym} 4567 39270 0 1 {name=l2099_4 lab=VDD}
N 4547 39290 4567 39290 {lab=VDD}
C {./lab_pin.sym} 4567 39290 0 1 {name=l2099_5 lab=VDD}
N 4547 39310 4567 39310 {lab=VSS}
C {./lab_pin.sym} 4567 39310 0 1 {name=l2099_6 lab=VSS}
N 4547 39330 4567 39330 {lab=VSS}
C {./lab_pin.sym} 4567 39330 0 1 {name=l2099_7 lab=VSS}
C {./nand2_1.sym} 0 39525 0 0 {name=Xn_2041}
N -92 39495 -112 39495 {lab=n_0451}
C {./lab_pin.sym} -112 39495 0 0 {name=l2100_0 lab=n_0451}
N -92 39515 -112 39515 {lab=n_0459}
C {./lab_pin.sym} -112 39515 0 0 {name=l2100_1 lab=n_0459}
N -92 39535 -112 39535 {lab=n_0460}
C {./lab_pin.sym} -112 39535 0 0 {name=l2100_2 lab=n_0460}
N -92 39555 -112 39555 {lab=VDD}
C {./lab_pin.sym} -112 39555 0 0 {name=l2100_3 lab=VDD}
N 92 39505 112 39505 {lab=VDD}
C {./lab_pin.sym} 112 39505 0 1 {name=l2100_4 lab=VDD}
N 92 39525 112 39525 {lab=VSS}
C {./lab_pin.sym} 112 39525 0 1 {name=l2100_5 lab=VSS}
N 92 39545 112 39545 {lab=VSS}
C {./lab_pin.sym} 112 39545 0 1 {name=l2100_6 lab=VSS}
C {./clkinv_1.sym} 405 39525 0 0 {name=Xn_2042}
N 313 39505 293 39505 {lab=n_0460}
C {./lab_pin.sym} 293 39505 0 0 {name=l2101_0 lab=n_0460}
N 313 39525 293 39525 {lab=n_0461}
C {./lab_pin.sym} 293 39525 0 0 {name=l2101_1 lab=n_0461}
N 313 39545 293 39545 {lab=VDD}
C {./lab_pin.sym} 293 39545 0 0 {name=l2101_2 lab=VDD}
N 497 39505 517 39505 {lab=VDD}
C {./lab_pin.sym} 517 39505 0 1 {name=l2101_3 lab=VDD}
N 497 39525 517 39525 {lab=VSS}
C {./lab_pin.sym} 517 39525 0 1 {name=l2101_4 lab=VSS}
N 497 39545 517 39545 {lab=VSS}
C {./lab_pin.sym} 517 39545 0 1 {name=l2101_5 lab=VSS}
C {./oai21_1.sym} 810 39525 0 0 {name=Xn_2043}
N 718 39495 698 39495 {lab=n_0449}
C {./lab_pin.sym} 698 39495 0 0 {name=l2102_0 lab=n_0449}
N 718 39515 698 39515 {lab=n_0457}
C {./lab_pin.sym} 698 39515 0 0 {name=l2102_1 lab=n_0457}
N 718 39535 698 39535 {lab=n_0461}
C {./lab_pin.sym} 698 39535 0 0 {name=l2102_2 lab=n_0461}
N 718 39555 698 39555 {lab=n_0462}
C {./lab_pin.sym} 698 39555 0 0 {name=l2102_3 lab=n_0462}
N 902 39495 922 39495 {lab=VDD}
C {./lab_pin.sym} 922 39495 0 1 {name=l2102_4 lab=VDD}
N 902 39515 922 39515 {lab=VDD}
C {./lab_pin.sym} 922 39515 0 1 {name=l2102_5 lab=VDD}
N 902 39535 922 39535 {lab=VSS}
C {./lab_pin.sym} 922 39535 0 1 {name=l2102_6 lab=VSS}
N 902 39555 922 39555 {lab=VSS}
C {./lab_pin.sym} 922 39555 0 1 {name=l2102_7 lab=VSS}
C {./oai21_1.sym} 1215 39525 0 0 {name=Xn_2044}
N 1123 39495 1103 39495 {lab=n_0458}
C {./lab_pin.sym} 1103 39495 0 0 {name=l2103_0 lab=n_0458}
N 1123 39515 1103 39515 {lab=n_0460}
C {./lab_pin.sym} 1103 39515 0 0 {name=l2103_1 lab=n_0460}
N 1123 39535 1103 39535 {lab=n_0456}
C {./lab_pin.sym} 1103 39535 0 0 {name=l2103_2 lab=n_0456}
N 1123 39555 1103 39555 {lab=n_0463}
C {./lab_pin.sym} 1103 39555 0 0 {name=l2103_3 lab=n_0463}
N 1307 39495 1327 39495 {lab=VDD}
C {./lab_pin.sym} 1327 39495 0 1 {name=l2103_4 lab=VDD}
N 1307 39515 1327 39515 {lab=VDD}
C {./lab_pin.sym} 1327 39515 0 1 {name=l2103_5 lab=VDD}
N 1307 39535 1327 39535 {lab=VSS}
C {./lab_pin.sym} 1327 39535 0 1 {name=l2103_6 lab=VSS}
N 1307 39555 1327 39555 {lab=VSS}
C {./lab_pin.sym} 1327 39555 0 1 {name=l2103_7 lab=VSS}
C {./xor2_1.sym} 1620 39525 0 0 {name=Xn_2045}
N 1528 39495 1508 39495 {lab=n_0456}
C {./lab_pin.sym} 1508 39495 0 0 {name=l2104_0 lab=n_0456}
N 1528 39515 1508 39515 {lab=n_0462}
C {./lab_pin.sym} 1508 39515 0 0 {name=l2104_1 lab=n_0462}
N 1528 39535 1508 39535 {lab=n_0014}
C {./lab_pin.sym} 1508 39535 0 0 {name=l2104_2 lab=n_0014}
N 1528 39555 1508 39555 {lab=VDD}
C {./lab_pin.sym} 1508 39555 0 0 {name=l2104_3 lab=VDD}
N 1712 39505 1732 39505 {lab=VDD}
C {./lab_pin.sym} 1732 39505 0 1 {name=l2104_4 lab=VDD}
N 1712 39525 1732 39525 {lab=VSS}
C {./lab_pin.sym} 1732 39525 0 1 {name=l2104_5 lab=VSS}
N 1712 39545 1732 39545 {lab=VSS}
C {./lab_pin.sym} 1732 39545 0 1 {name=l2104_6 lab=VSS}
C {./xor2_1.sym} 2025 39525 0 0 {name=Xn_2046}
N 1933 39495 1913 39495 {lab=out_cas_int_b23}
C {./lab_pin.sym} 1913 39495 0 0 {name=l2105_0 lab=out_cas_int_b23}
N 1933 39515 1913 39515 {lab=n_0585}
C {./lab_pin.sym} 1913 39515 0 0 {name=l2105_1 lab=n_0585}
N 1933 39535 1913 39535 {lab=n_0464}
C {./lab_pin.sym} 1913 39535 0 0 {name=l2105_2 lab=n_0464}
N 1933 39555 1913 39555 {lab=VDD}
C {./lab_pin.sym} 1913 39555 0 0 {name=l2105_3 lab=VDD}
N 2117 39505 2137 39505 {lab=VDD}
C {./lab_pin.sym} 2137 39505 0 1 {name=l2105_4 lab=VDD}
N 2117 39525 2137 39525 {lab=VSS}
C {./lab_pin.sym} 2137 39525 0 1 {name=l2105_5 lab=VSS}
N 2117 39545 2137 39545 {lab=VSS}
C {./lab_pin.sym} 2137 39545 0 1 {name=l2105_6 lab=VSS}
C {./xor2_1.sym} 2430 39525 0 0 {name=Xn_2047}
N 2338 39495 2318 39495 {lab=out_cas_int_b23}
C {./lab_pin.sym} 2318 39495 0 0 {name=l2106_0 lab=out_cas_int_b23}
N 2338 39515 2318 39515 {lab=u_cas_diff_u_diff1_in_min1_b23}
C {./lab_pin.sym} 2318 39515 0 0 {name=l2106_1 lab=u_cas_diff_u_diff1_in_min1_b23}
N 2338 39535 2318 39535 {lab=n_0465}
C {./lab_pin.sym} 2318 39535 0 0 {name=l2106_2 lab=n_0465}
N 2338 39555 2318 39555 {lab=VDD}
C {./lab_pin.sym} 2318 39555 0 0 {name=l2106_3 lab=VDD}
N 2522 39505 2542 39505 {lab=VDD}
C {./lab_pin.sym} 2542 39505 0 1 {name=l2106_4 lab=VDD}
N 2522 39525 2542 39525 {lab=VSS}
C {./lab_pin.sym} 2542 39525 0 1 {name=l2106_5 lab=VSS}
N 2522 39545 2542 39545 {lab=VSS}
C {./lab_pin.sym} 2542 39545 0 1 {name=l2106_6 lab=VSS}
C {./aoi211_1.sym} 2835 39525 0 0 {name=Xn_2048}
N 2743 39485 2723 39485 {lab=n_0462}
C {./lab_pin.sym} 2723 39485 0 0 {name=l2107_0 lab=n_0462}
N 2743 39505 2723 39505 {lab=n_0456}
C {./lab_pin.sym} 2723 39505 0 0 {name=l2107_1 lab=n_0456}
N 2743 39525 2723 39525 {lab=n_0453}
C {./lab_pin.sym} 2723 39525 0 0 {name=l2107_2 lab=n_0453}
N 2743 39545 2723 39545 {lab=n_0464}
C {./lab_pin.sym} 2723 39545 0 0 {name=l2107_3 lab=n_0464}
N 2743 39565 2723 39565 {lab=n_0466}
C {./lab_pin.sym} 2723 39565 0 0 {name=l2107_4 lab=n_0466}
N 2927 39495 2947 39495 {lab=VDD}
C {./lab_pin.sym} 2947 39495 0 1 {name=l2107_5 lab=VDD}
N 2927 39515 2947 39515 {lab=VDD}
C {./lab_pin.sym} 2947 39515 0 1 {name=l2107_6 lab=VDD}
N 2927 39535 2947 39535 {lab=VSS}
C {./lab_pin.sym} 2947 39535 0 1 {name=l2107_7 lab=VSS}
N 2927 39555 2947 39555 {lab=VSS}
C {./lab_pin.sym} 2947 39555 0 1 {name=l2107_8 lab=VSS}
C {./aoi21_1.sym} 3240 39525 0 0 {name=Xn_2049}
N 3148 39495 3128 39495 {lab=n_0454}
C {./lab_pin.sym} 3128 39495 0 0 {name=l2108_0 lab=n_0454}
N 3148 39515 3128 39515 {lab=n_0463}
C {./lab_pin.sym} 3128 39515 0 0 {name=l2108_1 lab=n_0463}
N 3148 39535 3128 39535 {lab=n_0465}
C {./lab_pin.sym} 3128 39535 0 0 {name=l2108_2 lab=n_0465}
N 3148 39555 3128 39555 {lab=n_0467}
C {./lab_pin.sym} 3128 39555 0 0 {name=l2108_3 lab=n_0467}
N 3332 39495 3352 39495 {lab=VDD}
C {./lab_pin.sym} 3352 39495 0 1 {name=l2108_4 lab=VDD}
N 3332 39515 3352 39515 {lab=VDD}
C {./lab_pin.sym} 3352 39515 0 1 {name=l2108_5 lab=VDD}
N 3332 39535 3352 39535 {lab=VSS}
C {./lab_pin.sym} 3352 39535 0 1 {name=l2108_6 lab=VSS}
N 3332 39555 3352 39555 {lab=VSS}
C {./lab_pin.sym} 3352 39555 0 1 {name=l2108_7 lab=VSS}
C {./nor2_1.sym} 3645 39525 0 0 {name=Xn_2050}
N 3553 39495 3533 39495 {lab=n_0466}
C {./lab_pin.sym} 3533 39495 0 0 {name=l2109_0 lab=n_0466}
N 3553 39515 3533 39515 {lab=n_0467}
C {./lab_pin.sym} 3533 39515 0 0 {name=l2109_1 lab=n_0467}
N 3553 39535 3533 39535 {lab=n_0015}
C {./lab_pin.sym} 3533 39535 0 0 {name=l2109_2 lab=n_0015}
N 3553 39555 3533 39555 {lab=VDD}
C {./lab_pin.sym} 3533 39555 0 0 {name=l2109_3 lab=VDD}
N 3737 39505 3757 39505 {lab=VDD}
C {./lab_pin.sym} 3757 39505 0 1 {name=l2109_4 lab=VDD}
N 3737 39525 3757 39525 {lab=VSS}
C {./lab_pin.sym} 3757 39525 0 1 {name=l2109_5 lab=VSS}
N 3737 39545 3757 39545 {lab=VSS}
C {./lab_pin.sym} 3757 39545 0 1 {name=l2109_6 lab=VSS}
C {./nor3_1.sym} 4050 39525 0 0 {name=Xn_2051}
N 3958 39495 3938 39495 {lab=n_0465}
C {./lab_pin.sym} 3938 39495 0 0 {name=l2110_0 lab=n_0465}
N 3958 39515 3938 39515 {lab=n_0455}
C {./lab_pin.sym} 3938 39515 0 0 {name=l2110_1 lab=n_0455}
N 3958 39535 3938 39535 {lab=n_0453}
C {./lab_pin.sym} 3938 39535 0 0 {name=l2110_2 lab=n_0453}
N 3958 39555 3938 39555 {lab=n_0468}
C {./lab_pin.sym} 3938 39555 0 0 {name=l2110_3 lab=n_0468}
N 4142 39495 4162 39495 {lab=VDD}
C {./lab_pin.sym} 4162 39495 0 1 {name=l2110_4 lab=VDD}
N 4142 39515 4162 39515 {lab=VDD}
C {./lab_pin.sym} 4162 39515 0 1 {name=l2110_5 lab=VDD}
N 4142 39535 4162 39535 {lab=VSS}
C {./lab_pin.sym} 4162 39535 0 1 {name=l2110_6 lab=VSS}
N 4142 39555 4162 39555 {lab=VSS}
C {./lab_pin.sym} 4162 39555 0 1 {name=l2110_7 lab=VSS}
C {./oai21_1.sym} 4455 39525 0 0 {name=Xn_2052}
N 4363 39495 4343 39495 {lab=n_0458}
C {./lab_pin.sym} 4343 39495 0 0 {name=l2111_0 lab=n_0458}
N 4363 39515 4343 39515 {lab=n_0460}
C {./lab_pin.sym} 4343 39515 0 0 {name=l2111_1 lab=n_0460}
N 4363 39535 4343 39535 {lab=n_0468}
C {./lab_pin.sym} 4343 39535 0 0 {name=l2111_2 lab=n_0468}
N 4363 39555 4343 39555 {lab=n_0469}
C {./lab_pin.sym} 4343 39555 0 0 {name=l2111_3 lab=n_0469}
N 4547 39495 4567 39495 {lab=VDD}
C {./lab_pin.sym} 4567 39495 0 1 {name=l2111_4 lab=VDD}
N 4547 39515 4567 39515 {lab=VDD}
C {./lab_pin.sym} 4567 39515 0 1 {name=l2111_5 lab=VDD}
N 4547 39535 4567 39535 {lab=VSS}
C {./lab_pin.sym} 4567 39535 0 1 {name=l2111_6 lab=VSS}
N 4547 39555 4567 39555 {lab=VSS}
C {./lab_pin.sym} 4567 39555 0 1 {name=l2111_7 lab=VSS}
C {./aoi211_1.sym} 0 39750 0 0 {name=Xn_2053}
N -92 39710 -112 39710 {lab=n_0496}
C {./lab_pin.sym} -112 39710 0 0 {name=l2112_0 lab=n_0496}
N -92 39730 -112 39730 {lab=u_cas_diff_u_diff1_in_min1_b23}
C {./lab_pin.sym} -112 39730 0 0 {name=l2112_1 lab=u_cas_diff_u_diff1_in_min1_b23}
N -92 39750 -112 39750 {lab=n_0495}
C {./lab_pin.sym} -112 39750 0 0 {name=l2112_2 lab=n_0495}
N -92 39770 -112 39770 {lab=u_cas_diff_u_diff1_in_min1_b22}
C {./lab_pin.sym} -112 39770 0 0 {name=l2112_3 lab=u_cas_diff_u_diff1_in_min1_b22}
N -92 39790 -112 39790 {lab=n_0470}
C {./lab_pin.sym} -112 39790 0 0 {name=l2112_4 lab=n_0470}
N 92 39720 112 39720 {lab=VDD}
C {./lab_pin.sym} 112 39720 0 1 {name=l2112_5 lab=VDD}
N 92 39740 112 39740 {lab=VDD}
C {./lab_pin.sym} 112 39740 0 1 {name=l2112_6 lab=VDD}
N 92 39760 112 39760 {lab=VSS}
C {./lab_pin.sym} 112 39760 0 1 {name=l2112_7 lab=VSS}
N 92 39780 112 39780 {lab=VSS}
C {./lab_pin.sym} 112 39780 0 1 {name=l2112_8 lab=VSS}
C {./oai211_1.sym} 405 39750 0 0 {name=Xn_2054}
N 313 39710 293 39710 {lab=n_0585}
C {./lab_pin.sym} 293 39710 0 0 {name=l2113_0 lab=n_0585}
N 313 39730 293 39730 {lab=out_cas_int_b23}
C {./lab_pin.sym} 293 39730 0 0 {name=l2113_1 lab=out_cas_int_b23}
N 313 39750 293 39750 {lab=n_0584}
C {./lab_pin.sym} 293 39750 0 0 {name=l2113_2 lab=n_0584}
N 313 39770 293 39770 {lab=out_cas_int_b22}
C {./lab_pin.sym} 293 39770 0 0 {name=l2113_3 lab=out_cas_int_b22}
N 313 39790 293 39790 {lab=n_0471}
C {./lab_pin.sym} 293 39790 0 0 {name=l2113_4 lab=n_0471}
N 497 39720 517 39720 {lab=VDD}
C {./lab_pin.sym} 517 39720 0 1 {name=l2113_5 lab=VDD}
N 497 39740 517 39740 {lab=VDD}
C {./lab_pin.sym} 517 39740 0 1 {name=l2113_6 lab=VDD}
N 497 39760 517 39760 {lab=VSS}
C {./lab_pin.sym} 517 39760 0 1 {name=l2113_7 lab=VSS}
N 497 39780 517 39780 {lab=VSS}
C {./lab_pin.sym} 517 39780 0 1 {name=l2113_8 lab=VSS}
C {./aoi21_1.sym} 810 39750 0 0 {name=Xn_2055}
N 718 39720 698 39720 {lab=out_cas_int_b23}
C {./lab_pin.sym} 698 39720 0 0 {name=l2114_0 lab=out_cas_int_b23}
N 718 39740 698 39740 {lab=n_0585}
C {./lab_pin.sym} 698 39740 0 0 {name=l2114_1 lab=n_0585}
N 718 39760 698 39760 {lab=n_0470}
C {./lab_pin.sym} 698 39760 0 0 {name=l2114_2 lab=n_0470}
N 718 39780 698 39780 {lab=n_0472}
C {./lab_pin.sym} 698 39780 0 0 {name=l2114_3 lab=n_0472}
N 902 39720 922 39720 {lab=VDD}
C {./lab_pin.sym} 922 39720 0 1 {name=l2114_4 lab=VDD}
N 902 39740 922 39740 {lab=VDD}
C {./lab_pin.sym} 922 39740 0 1 {name=l2114_5 lab=VDD}
N 902 39760 922 39760 {lab=VSS}
C {./lab_pin.sym} 922 39760 0 1 {name=l2114_6 lab=VSS}
N 902 39780 922 39780 {lab=VSS}
C {./lab_pin.sym} 922 39780 0 1 {name=l2114_7 lab=VSS}
C {./oai21_1.sym} 1215 39750 0 0 {name=Xn_2056}
N 1123 39720 1103 39720 {lab=n_0496}
C {./lab_pin.sym} 1103 39720 0 0 {name=l2115_0 lab=n_0496}
N 1123 39740 1103 39740 {lab=u_cas_diff_u_diff1_in_min1_b23}
C {./lab_pin.sym} 1103 39740 0 0 {name=l2115_1 lab=u_cas_diff_u_diff1_in_min1_b23}
N 1123 39760 1103 39760 {lab=n_0471}
C {./lab_pin.sym} 1103 39760 0 0 {name=l2115_2 lab=n_0471}
N 1123 39780 1103 39780 {lab=n_0473}
C {./lab_pin.sym} 1103 39780 0 0 {name=l2115_3 lab=n_0473}
N 1307 39720 1327 39720 {lab=VDD}
C {./lab_pin.sym} 1327 39720 0 1 {name=l2115_4 lab=VDD}
N 1307 39740 1327 39740 {lab=VDD}
C {./lab_pin.sym} 1327 39740 0 1 {name=l2115_5 lab=VDD}
N 1307 39760 1327 39760 {lab=VSS}
C {./lab_pin.sym} 1327 39760 0 1 {name=l2115_6 lab=VSS}
N 1307 39780 1327 39780 {lab=VSS}
C {./lab_pin.sym} 1327 39780 0 1 {name=l2115_7 lab=VSS}
C {./xor2_1.sym} 1620 39750 0 0 {name=Xn_2057}
N 1528 39720 1508 39720 {lab=out_cas_int_b24}
C {./lab_pin.sym} 1508 39720 0 0 {name=l2116_0 lab=out_cas_int_b24}
N 1528 39740 1508 39740 {lab=u_cas_diff_u_diff1_in_min1_b24}
C {./lab_pin.sym} 1508 39740 0 0 {name=l2116_1 lab=u_cas_diff_u_diff1_in_min1_b24}
N 1528 39760 1508 39760 {lab=n_0474}
C {./lab_pin.sym} 1508 39760 0 0 {name=l2116_2 lab=n_0474}
N 1528 39780 1508 39780 {lab=VDD}
C {./lab_pin.sym} 1508 39780 0 0 {name=l2116_3 lab=VDD}
N 1712 39730 1732 39730 {lab=VDD}
C {./lab_pin.sym} 1732 39730 0 1 {name=l2116_4 lab=VDD}
N 1712 39750 1732 39750 {lab=VSS}
C {./lab_pin.sym} 1732 39750 0 1 {name=l2116_5 lab=VSS}
N 1712 39770 1732 39770 {lab=VSS}
C {./lab_pin.sym} 1732 39770 0 1 {name=l2116_6 lab=VSS}
C {./xnor2_1.sym} 2025 39750 0 0 {name=Xn_2058}
N 1933 39720 1913 39720 {lab=out_cas_int_b24}
C {./lab_pin.sym} 1913 39720 0 0 {name=l2117_0 lab=out_cas_int_b24}
N 1933 39740 1913 39740 {lab=u_cas_diff_u_diff1_in_min1_b24}
C {./lab_pin.sym} 1913 39740 0 0 {name=l2117_1 lab=u_cas_diff_u_diff1_in_min1_b24}
N 1933 39760 1913 39760 {lab=n_0475}
C {./lab_pin.sym} 1913 39760 0 0 {name=l2117_2 lab=n_0475}
N 1933 39780 1913 39780 {lab=VDD}
C {./lab_pin.sym} 1913 39780 0 0 {name=l2117_3 lab=VDD}
N 2117 39730 2137 39730 {lab=VDD}
C {./lab_pin.sym} 2137 39730 0 1 {name=l2117_4 lab=VDD}
N 2117 39750 2137 39750 {lab=VSS}
C {./lab_pin.sym} 2137 39750 0 1 {name=l2117_5 lab=VSS}
N 2117 39770 2137 39770 {lab=VSS}
C {./lab_pin.sym} 2137 39770 0 1 {name=l2117_6 lab=VSS}
C {./aoi21_1.sym} 2430 39750 0 0 {name=Xn_2059}
N 2338 39720 2318 39720 {lab=n_0469}
C {./lab_pin.sym} 2318 39720 0 0 {name=l2118_0 lab=n_0469}
N 2338 39740 2318 39740 {lab=n_0472}
C {./lab_pin.sym} 2318 39740 0 0 {name=l2118_1 lab=n_0472}
N 2338 39760 2318 39760 {lab=n_0474}
C {./lab_pin.sym} 2318 39760 0 0 {name=l2118_2 lab=n_0474}
N 2338 39780 2318 39780 {lab=n_0476}
C {./lab_pin.sym} 2318 39780 0 0 {name=l2118_3 lab=n_0476}
N 2522 39720 2542 39720 {lab=VDD}
C {./lab_pin.sym} 2542 39720 0 1 {name=l2118_4 lab=VDD}
N 2522 39740 2542 39740 {lab=VDD}
C {./lab_pin.sym} 2542 39740 0 1 {name=l2118_5 lab=VDD}
N 2522 39760 2542 39760 {lab=VSS}
C {./lab_pin.sym} 2542 39760 0 1 {name=l2118_6 lab=VSS}
N 2522 39780 2542 39780 {lab=VSS}
C {./lab_pin.sym} 2542 39780 0 1 {name=l2118_7 lab=VSS}
C {./aoi211_1.sym} 2835 39750 0 0 {name=Xn_2060}
N 2743 39710 2723 39710 {lab=n_0462}
C {./lab_pin.sym} 2723 39710 0 0 {name=l2119_0 lab=n_0462}
N 2743 39730 2723 39730 {lab=n_0468}
C {./lab_pin.sym} 2723 39730 0 0 {name=l2119_1 lab=n_0468}
N 2743 39750 2723 39750 {lab=n_0473}
C {./lab_pin.sym} 2723 39750 0 0 {name=l2119_2 lab=n_0473}
N 2743 39770 2723 39770 {lab=n_0475}
C {./lab_pin.sym} 2723 39770 0 0 {name=l2119_3 lab=n_0475}
N 2743 39790 2723 39790 {lab=n_0477}
C {./lab_pin.sym} 2723 39790 0 0 {name=l2119_4 lab=n_0477}
N 2927 39720 2947 39720 {lab=VDD}
C {./lab_pin.sym} 2947 39720 0 1 {name=l2119_5 lab=VDD}
N 2927 39740 2947 39740 {lab=VDD}
C {./lab_pin.sym} 2947 39740 0 1 {name=l2119_6 lab=VDD}
N 2927 39760 2947 39760 {lab=VSS}
C {./lab_pin.sym} 2947 39760 0 1 {name=l2119_7 lab=VSS}
N 2927 39780 2947 39780 {lab=VSS}
C {./lab_pin.sym} 2947 39780 0 1 {name=l2119_8 lab=VSS}
C {./nor2_1.sym} 3240 39750 0 0 {name=Xn_2061}
N 3148 39720 3128 39720 {lab=n_0476}
C {./lab_pin.sym} 3128 39720 0 0 {name=l2120_0 lab=n_0476}
N 3148 39740 3128 39740 {lab=n_0477}
C {./lab_pin.sym} 3128 39740 0 0 {name=l2120_1 lab=n_0477}
N 3148 39760 3128 39760 {lab=n_0016}
C {./lab_pin.sym} 3128 39760 0 0 {name=l2120_2 lab=n_0016}
N 3148 39780 3128 39780 {lab=VDD}
C {./lab_pin.sym} 3128 39780 0 0 {name=l2120_3 lab=VDD}
N 3332 39730 3352 39730 {lab=VDD}
C {./lab_pin.sym} 3352 39730 0 1 {name=l2120_4 lab=VDD}
N 3332 39750 3352 39750 {lab=VSS}
C {./lab_pin.sym} 3352 39750 0 1 {name=l2120_5 lab=VSS}
N 3332 39770 3352 39770 {lab=VSS}
C {./lab_pin.sym} 3352 39770 0 1 {name=l2120_6 lab=VSS}
C {./xnor2_1.sym} 3645 39750 0 0 {name=Xn_2062}
N 3553 39720 3533 39720 {lab=u_clock_div_counter_b3}
C {./lab_pin.sym} 3533 39720 0 0 {name=l2121_0 lab=u_clock_div_counter_b3}
N 3553 39740 3533 39740 {lab=n_0587}
C {./lab_pin.sym} 3533 39740 0 0 {name=l2121_1 lab=n_0587}
N 3553 39760 3533 39760 {lab=n_0140}
C {./lab_pin.sym} 3533 39760 0 0 {name=l2121_2 lab=n_0140}
N 3553 39780 3533 39780 {lab=VDD}
C {./lab_pin.sym} 3533 39780 0 0 {name=l2121_3 lab=VDD}
N 3737 39730 3757 39730 {lab=VDD}
C {./lab_pin.sym} 3757 39730 0 1 {name=l2121_4 lab=VDD}
N 3737 39750 3757 39750 {lab=VSS}
C {./lab_pin.sym} 3757 39750 0 1 {name=l2121_5 lab=VSS}
N 3737 39770 3757 39770 {lab=VSS}
C {./lab_pin.sym} 3757 39770 0 1 {name=l2121_6 lab=VSS}
C {./xor2_1.sym} 4050 39750 0 0 {name=Xn_2063}
N 3958 39720 3938 39720 {lab=u_cas_int_out_int2_b0}
C {./lab_pin.sym} 3938 39720 0 0 {name=l2122_0 lab=u_cas_int_out_int2_b0}
N 3958 39740 3938 39740 {lab=out_cas_int_b0}
C {./lab_pin.sym} 3938 39740 0 0 {name=l2122_1 lab=out_cas_int_b0}
N 3958 39760 3938 39760 {lab=n_0112}
C {./lab_pin.sym} 3938 39760 0 0 {name=l2122_2 lab=n_0112}
N 3958 39780 3938 39780 {lab=VDD}
C {./lab_pin.sym} 3938 39780 0 0 {name=l2122_3 lab=VDD}
N 4142 39730 4162 39730 {lab=VDD}
C {./lab_pin.sym} 4162 39730 0 1 {name=l2122_4 lab=VDD}
N 4142 39750 4162 39750 {lab=VSS}
C {./lab_pin.sym} 4162 39750 0 1 {name=l2122_5 lab=VSS}
N 4142 39770 4162 39770 {lab=VSS}
C {./lab_pin.sym} 4162 39770 0 1 {name=l2122_6 lab=VSS}
C {./xnor2_1.sym} 4455 39750 0 0 {name=Xn_2064}
N 4363 39720 4343 39720 {lab=u_clock_div_counter_b2}
C {./lab_pin.sym} 4343 39720 0 0 {name=l2123_0 lab=u_clock_div_counter_b2}
N 4363 39740 4343 39740 {lab=n_0586}
C {./lab_pin.sym} 4343 39740 0 0 {name=l2123_1 lab=n_0586}
N 4363 39760 4343 39760 {lab=n_0139}
C {./lab_pin.sym} 4343 39760 0 0 {name=l2123_2 lab=n_0139}
N 4363 39780 4343 39780 {lab=VDD}
C {./lab_pin.sym} 4343 39780 0 0 {name=l2123_3 lab=VDD}
N 4547 39730 4567 39730 {lab=VDD}
C {./lab_pin.sym} 4567 39730 0 1 {name=l2123_4 lab=VDD}
N 4547 39750 4567 39750 {lab=VSS}
C {./lab_pin.sym} 4567 39750 0 1 {name=l2123_5 lab=VSS}
N 4547 39770 4567 39770 {lab=VSS}
C {./lab_pin.sym} 4567 39770 0 1 {name=l2123_6 lab=VSS}
C {./xor2_1.sym} 0 39975 0 0 {name=Xn_2065}
N -92 39945 -112 39945 {lab=out_cas_int_b0}
C {./lab_pin.sym} -112 39945 0 0 {name=l2124_0 lab=out_cas_int_b0}
N -92 39965 -112 39965 {lab=u_cas_diff_u_diff1_in_min1_b0}
C {./lab_pin.sym} -112 39965 0 0 {name=l2124_1 lab=u_cas_diff_u_diff1_in_min1_b0}
N -92 39985 -112 39985 {lab=n_0000}
C {./lab_pin.sym} -112 39985 0 0 {name=l2124_2 lab=n_0000}
N -92 40005 -112 40005 {lab=VDD}
C {./lab_pin.sym} -112 40005 0 0 {name=l2124_3 lab=VDD}
N 92 39955 112 39955 {lab=VDD}
C {./lab_pin.sym} 112 39955 0 1 {name=l2124_4 lab=VDD}
N 92 39975 112 39975 {lab=VSS}
C {./lab_pin.sym} 112 39975 0 1 {name=l2124_5 lab=VSS}
N 92 39995 112 39995 {lab=VSS}
C {./lab_pin.sym} 112 39995 0 1 {name=l2124_6 lab=VSS}
C {./xor2_1.sym} 405 39975 0 0 {name=Xn_2066}
N 313 39945 293 39945 {lab=u_clock_div_counter_b0}
C {./lab_pin.sym} 293 39945 0 0 {name=l2125_0 lab=u_clock_div_counter_b0}
N 313 39965 293 39965 {lab=u_clock_div_counter_b1}
C {./lab_pin.sym} 293 39965 0 0 {name=l2125_1 lab=u_clock_div_counter_b1}
N 313 39985 293 39985 {lab=n_0138}
C {./lab_pin.sym} 293 39985 0 0 {name=l2125_2 lab=n_0138}
N 313 40005 293 40005 {lab=VDD}
C {./lab_pin.sym} 293 40005 0 0 {name=l2125_3 lab=VDD}
N 497 39955 517 39955 {lab=VDD}
C {./lab_pin.sym} 517 39955 0 1 {name=l2125_4 lab=VDD}
N 497 39975 517 39975 {lab=VSS}
C {./lab_pin.sym} 517 39975 0 1 {name=l2125_5 lab=VSS}
N 497 39995 517 39995 {lab=VSS}
C {./lab_pin.sym} 517 39995 0 1 {name=l2125_6 lab=VSS}
C {./xor2_1.sym} 810 39975 0 0 {name=Xn_2067}
N 718 39945 698 39945 {lab=u_cas_int_out_int1_b0}
C {./lab_pin.sym} 698 39945 0 0 {name=l2126_0 lab=u_cas_int_out_int1_b0}
N 718 39965 698 39965 {lab=net1}
C {./lab_pin.sym} 698 39965 0 0 {name=l2126_1 lab=net1}
N 718 39985 698 39985 {lab=n_0062}
C {./lab_pin.sym} 698 39985 0 0 {name=l2126_2 lab=n_0062}
N 718 40005 698 40005 {lab=VDD}
C {./lab_pin.sym} 698 40005 0 0 {name=l2126_3 lab=VDD}
N 902 39955 922 39955 {lab=VDD}
C {./lab_pin.sym} 922 39955 0 1 {name=l2126_4 lab=VDD}
N 902 39975 922 39975 {lab=VSS}
C {./lab_pin.sym} 922 39975 0 1 {name=l2126_5 lab=VSS}
N 902 39995 922 39995 {lab=VSS}
C {./lab_pin.sym} 922 39995 0 1 {name=l2126_6 lab=VSS}
C {./xor2_1.sym} 1215 39975 0 0 {name=Xn_2068}
N 1123 39945 1103 39945 {lab=u_cas_int_out_int2_b0}
C {./lab_pin.sym} 1103 39945 0 0 {name=l2127_0 lab=u_cas_int_out_int2_b0}
N 1123 39965 1103 39965 {lab=u_cas_int_out_int1_b0}
C {./lab_pin.sym} 1103 39965 0 0 {name=l2127_1 lab=u_cas_int_out_int1_b0}
N 1123 39985 1103 39985 {lab=n_0087}
C {./lab_pin.sym} 1103 39985 0 0 {name=l2127_2 lab=n_0087}
N 1123 40005 1103 40005 {lab=VDD}
C {./lab_pin.sym} 1103 40005 0 0 {name=l2127_3 lab=VDD}
N 1307 39955 1327 39955 {lab=VDD}
C {./lab_pin.sym} 1327 39955 0 1 {name=l2127_4 lab=VDD}
N 1307 39975 1327 39975 {lab=VSS}
C {./lab_pin.sym} 1327 39975 0 1 {name=l2127_5 lab=VSS}
N 1307 39995 1327 39995 {lab=VSS}
C {./lab_pin.sym} 1327 39995 0 1 {name=l2127_6 lab=VSS}
C {./xor2_1.sym} 1620 39975 0 0 {name=Xn_2069}
N 1528 39945 1508 39945 {lab=u_cas_diff_u_diff2_in_min1_b0}
C {./lab_pin.sym} 1508 39945 0 0 {name=l2128_0 lab=u_cas_diff_u_diff2_in_min1_b0}
N 1528 39965 1508 39965 {lab=u_cas_diff_out_diff1_b0}
C {./lab_pin.sym} 1508 39965 0 0 {name=l2128_1 lab=u_cas_diff_out_diff1_b0}
N 1528 39985 1508 39985 {lab=n_0025}
C {./lab_pin.sym} 1508 39985 0 0 {name=l2128_2 lab=n_0025}
N 1528 40005 1508 40005 {lab=VDD}
C {./lab_pin.sym} 1508 40005 0 0 {name=l2128_3 lab=VDD}
N 1712 39955 1732 39955 {lab=VDD}
C {./lab_pin.sym} 1732 39955 0 1 {name=l2128_4 lab=VDD}
N 1712 39975 1732 39975 {lab=VSS}
C {./lab_pin.sym} 1732 39975 0 1 {name=l2128_5 lab=VSS}
N 1712 39995 1732 39995 {lab=VSS}
C {./lab_pin.sym} 1732 39995 0 1 {name=l2128_6 lab=VSS}
C {./dffrnq_1.sym} 2025 39975 0 0 {name=Xn_2070}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__dffrnq_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -50 72 -50 {}
L 4 72 -50 72 50 {}
L 4 72 50 -72 50 {}
L 4 -72 50 -72 -50 {}
T {@name} -72 -70 0 0 0.33 0.33 {}
T {dffrnq_1} -68 39 0 0 0.2 0.2 {}
L 4 -92 -30 -72 -30 {}
T {D} -66 -35 0 0 0.16 0.16 {}
L 4 -92 -10 -72 -10 {}
T {RN} -66 -15 0 0 0.16 0.16 {}
L 4 -92 10 -72 10 {}
T {CLK} -66 5 0 0 0.16 0.16 {}
L 4 -92 30 -72 30 {}
T {Q} -66 25 0 0 0.16 0.16 {}
L 4 92 -30 72 -30 {}
T {VDD} 50.2 -35 0 0 0.16 0.16 {}
L 4 92 -10 72 -10 {}
T {VNW} 50.2 -15 0 0 0.16 0.16 {}
L 4 92 10 72 10 {}
T {VPW} 50.2 5 0 0 0.16 0.16 {}
L 4 92 30 72 30 {}
T {VSS} 50.2 25 0 0 0.16 0.16 {}
B 5 -94 -32 -90 -28 {name=D dir=inout sim_pinnumber=1}
B 5 -94 -12 -90 -8 {name=RN dir=inout sim_pinnumber=2}
B 5 -94 8 -90 12 {name=CLK dir=inout sim_pinnumber=3}
B 5 -94 28 -90 32 {name=Q dir=inout sim_pinnumber=4}
B 5 90 -32 94 -28 {name=VDD dir=inout sim_pinnumber=5}
B 5 90 -12 94 -8 {name=VNW dir=inout sim_pinnumber=6}
B 5 90 8 94 12 {name=VPW dir=inout sim_pinnumber=7}
B 5 90 28 94 32 {name=VSS dir=inout sim_pinnumber=8}
]
N 1933 39945 1913 39945 {lab=n_0112}
C {./lab_pin.sym} 1913 39945 0 0 {name=l2129_0 lab=n_0112}
N 1933 39965 1913 39965 {lab=net21}
C {./lab_pin.sym} 1913 39965 0 0 {name=l2129_1 lab=net21}
N 1933 39985 1913 39985 {lab=clknet_3_2__leaf_clk}
C {./lab_pin.sym} 1913 39985 0 0 {name=l2129_2 lab=clknet_3_2__leaf_clk}
N 1933 40005 1913 40005 {lab=out_cas_int_b0}
C {./lab_pin.sym} 1913 40005 0 0 {name=l2129_3 lab=out_cas_int_b0}
N 2117 39945 2137 39945 {lab=VDD}
C {./lab_pin.sym} 2137 39945 0 1 {name=l2129_4 lab=VDD}
N 2117 39965 2137 39965 {lab=VDD}
C {./lab_pin.sym} 2137 39965 0 1 {name=l2129_5 lab=VDD}
N 2117 39985 2137 39985 {lab=VSS}
C {./lab_pin.sym} 2137 39985 0 1 {name=l2129_6 lab=VSS}
N 2117 40005 2137 40005 {lab=VSS}
C {./lab_pin.sym} 2137 40005 0 1 {name=l2129_7 lab=VSS}
C {./dffrnq_1.sym} 2430 39975 0 0 {name=Xn_2071}
N 2338 39945 2318 39945 {lab=n_0123}
C {./lab_pin.sym} 2318 39945 0 0 {name=l2130_0 lab=n_0123}
N 2338 39965 2318 39965 {lab=net21}
C {./lab_pin.sym} 2318 39965 0 0 {name=l2130_1 lab=net21}
N 2338 39985 2318 39985 {lab=clknet_3_2__leaf_clk}
C {./lab_pin.sym} 2318 39985 0 0 {name=l2130_2 lab=clknet_3_2__leaf_clk}
N 2338 40005 2318 40005 {lab=out_cas_int_b1}
C {./lab_pin.sym} 2318 40005 0 0 {name=l2130_3 lab=out_cas_int_b1}
N 2522 39945 2542 39945 {lab=VDD}
C {./lab_pin.sym} 2542 39945 0 1 {name=l2130_4 lab=VDD}
N 2522 39965 2542 39965 {lab=VDD}
C {./lab_pin.sym} 2542 39965 0 1 {name=l2130_5 lab=VDD}
N 2522 39985 2542 39985 {lab=VSS}
C {./lab_pin.sym} 2542 39985 0 1 {name=l2130_6 lab=VSS}
N 2522 40005 2542 40005 {lab=VSS}
C {./lab_pin.sym} 2542 40005 0 1 {name=l2130_7 lab=VSS}
C {./dffrnq_1.sym} 2835 39975 0 0 {name=Xn_2072}
N 2743 39945 2723 39945 {lab=n_0129}
C {./lab_pin.sym} 2723 39945 0 0 {name=l2131_0 lab=n_0129}
N 2743 39965 2723 39965 {lab=net18}
C {./lab_pin.sym} 2723 39965 0 0 {name=l2131_1 lab=net18}
N 2743 39985 2723 39985 {lab=clknet_3_2__leaf_clk}
C {./lab_pin.sym} 2723 39985 0 0 {name=l2131_2 lab=clknet_3_2__leaf_clk}
N 2743 40005 2723 40005 {lab=out_cas_int_b2}
C {./lab_pin.sym} 2723 40005 0 0 {name=l2131_3 lab=out_cas_int_b2}
N 2927 39945 2947 39945 {lab=VDD}
C {./lab_pin.sym} 2947 39945 0 1 {name=l2131_4 lab=VDD}
N 2927 39965 2947 39965 {lab=VDD}
C {./lab_pin.sym} 2947 39965 0 1 {name=l2131_5 lab=VDD}
N 2927 39985 2947 39985 {lab=VSS}
C {./lab_pin.sym} 2947 39985 0 1 {name=l2131_6 lab=VSS}
N 2927 40005 2947 40005 {lab=VSS}
C {./lab_pin.sym} 2947 40005 0 1 {name=l2131_7 lab=VSS}
C {./dffrnq_1.sym} 3240 39975 0 0 {name=Xn_2073}
N 3148 39945 3128 39945 {lab=n_0130}
C {./lab_pin.sym} 3128 39945 0 0 {name=l2132_0 lab=n_0130}
N 3148 39965 3128 39965 {lab=net18}
C {./lab_pin.sym} 3128 39965 0 0 {name=l2132_1 lab=net18}
N 3148 39985 3128 39985 {lab=clknet_3_2__leaf_clk}
C {./lab_pin.sym} 3128 39985 0 0 {name=l2132_2 lab=clknet_3_2__leaf_clk}
N 3148 40005 3128 40005 {lab=out_cas_int_b3}
C {./lab_pin.sym} 3128 40005 0 0 {name=l2132_3 lab=out_cas_int_b3}
N 3332 39945 3352 39945 {lab=VDD}
C {./lab_pin.sym} 3352 39945 0 1 {name=l2132_4 lab=VDD}
N 3332 39965 3352 39965 {lab=VDD}
C {./lab_pin.sym} 3352 39965 0 1 {name=l2132_5 lab=VDD}
N 3332 39985 3352 39985 {lab=VSS}
C {./lab_pin.sym} 3352 39985 0 1 {name=l2132_6 lab=VSS}
N 3332 40005 3352 40005 {lab=VSS}
C {./lab_pin.sym} 3352 40005 0 1 {name=l2132_7 lab=VSS}
C {./dffrnq_1.sym} 3645 39975 0 0 {name=Xn_2074}
N 3553 39945 3533 39945 {lab=n_0131}
C {./lab_pin.sym} 3533 39945 0 0 {name=l2133_0 lab=n_0131}
N 3553 39965 3533 39965 {lab=net18}
C {./lab_pin.sym} 3533 39965 0 0 {name=l2133_1 lab=net18}
N 3553 39985 3533 39985 {lab=clknet_3_2__leaf_clk}
C {./lab_pin.sym} 3533 39985 0 0 {name=l2133_2 lab=clknet_3_2__leaf_clk}
N 3553 40005 3533 40005 {lab=out_cas_int_b4}
C {./lab_pin.sym} 3533 40005 0 0 {name=l2133_3 lab=out_cas_int_b4}
N 3737 39945 3757 39945 {lab=VDD}
C {./lab_pin.sym} 3757 39945 0 1 {name=l2133_4 lab=VDD}
N 3737 39965 3757 39965 {lab=VDD}
C {./lab_pin.sym} 3757 39965 0 1 {name=l2133_5 lab=VDD}
N 3737 39985 3757 39985 {lab=VSS}
C {./lab_pin.sym} 3757 39985 0 1 {name=l2133_6 lab=VSS}
N 3737 40005 3757 40005 {lab=VSS}
C {./lab_pin.sym} 3757 40005 0 1 {name=l2133_7 lab=VSS}
C {./dffrnq_1.sym} 4050 39975 0 0 {name=Xn_2075}
N 3958 39945 3938 39945 {lab=n_0132}
C {./lab_pin.sym} 3938 39945 0 0 {name=l2134_0 lab=n_0132}
N 3958 39965 3938 39965 {lab=net18}
C {./lab_pin.sym} 3938 39965 0 0 {name=l2134_1 lab=net18}
N 3958 39985 3938 39985 {lab=clknet_3_2__leaf_clk}
C {./lab_pin.sym} 3938 39985 0 0 {name=l2134_2 lab=clknet_3_2__leaf_clk}
N 3958 40005 3938 40005 {lab=out_cas_int_b5}
C {./lab_pin.sym} 3938 40005 0 0 {name=l2134_3 lab=out_cas_int_b5}
N 4142 39945 4162 39945 {lab=VDD}
C {./lab_pin.sym} 4162 39945 0 1 {name=l2134_4 lab=VDD}
N 4142 39965 4162 39965 {lab=VDD}
C {./lab_pin.sym} 4162 39965 0 1 {name=l2134_5 lab=VDD}
N 4142 39985 4162 39985 {lab=VSS}
C {./lab_pin.sym} 4162 39985 0 1 {name=l2134_6 lab=VSS}
N 4142 40005 4162 40005 {lab=VSS}
C {./lab_pin.sym} 4162 40005 0 1 {name=l2134_7 lab=VSS}
C {./dffrnq_1.sym} 4455 39975 0 0 {name=Xn_2076}
N 4363 39945 4343 39945 {lab=n_0133}
C {./lab_pin.sym} 4343 39945 0 0 {name=l2135_0 lab=n_0133}
N 4363 39965 4343 39965 {lab=net18}
C {./lab_pin.sym} 4343 39965 0 0 {name=l2135_1 lab=net18}
N 4363 39985 4343 39985 {lab=clknet_3_3__leaf_clk}
C {./lab_pin.sym} 4343 39985 0 0 {name=l2135_2 lab=clknet_3_3__leaf_clk}
N 4363 40005 4343 40005 {lab=out_cas_int_b6}
C {./lab_pin.sym} 4343 40005 0 0 {name=l2135_3 lab=out_cas_int_b6}
N 4547 39945 4567 39945 {lab=VDD}
C {./lab_pin.sym} 4567 39945 0 1 {name=l2135_4 lab=VDD}
N 4547 39965 4567 39965 {lab=VDD}
C {./lab_pin.sym} 4567 39965 0 1 {name=l2135_5 lab=VDD}
N 4547 39985 4567 39985 {lab=VSS}
C {./lab_pin.sym} 4567 39985 0 1 {name=l2135_6 lab=VSS}
N 4547 40005 4567 40005 {lab=VSS}
C {./lab_pin.sym} 4567 40005 0 1 {name=l2135_7 lab=VSS}
C {./dffrnq_1.sym} 0 40200 0 0 {name=Xn_2077}
N -92 40170 -112 40170 {lab=n_0134}
C {./lab_pin.sym} -112 40170 0 0 {name=l2136_0 lab=n_0134}
N -92 40190 -112 40190 {lab=net18}
C {./lab_pin.sym} -112 40190 0 0 {name=l2136_1 lab=net18}
N -92 40210 -112 40210 {lab=clknet_3_3__leaf_clk}
C {./lab_pin.sym} -112 40210 0 0 {name=l2136_2 lab=clknet_3_3__leaf_clk}
N -92 40230 -112 40230 {lab=out_cas_int_b7}
C {./lab_pin.sym} -112 40230 0 0 {name=l2136_3 lab=out_cas_int_b7}
N 92 40170 112 40170 {lab=VDD}
C {./lab_pin.sym} 112 40170 0 1 {name=l2136_4 lab=VDD}
N 92 40190 112 40190 {lab=VDD}
C {./lab_pin.sym} 112 40190 0 1 {name=l2136_5 lab=VDD}
N 92 40210 112 40210 {lab=VSS}
C {./lab_pin.sym} 112 40210 0 1 {name=l2136_6 lab=VSS}
N 92 40230 112 40230 {lab=VSS}
C {./lab_pin.sym} 112 40230 0 1 {name=l2136_7 lab=VSS}
C {./dffrnq_1.sym} 405 40200 0 0 {name=Xn_2078}
N 313 40170 293 40170 {lab=n_0135}
C {./lab_pin.sym} 293 40170 0 0 {name=l2137_0 lab=n_0135}
N 313 40190 293 40190 {lab=net18}
C {./lab_pin.sym} 293 40190 0 0 {name=l2137_1 lab=net18}
N 313 40210 293 40210 {lab=clknet_3_3__leaf_clk}
C {./lab_pin.sym} 293 40210 0 0 {name=l2137_2 lab=clknet_3_3__leaf_clk}
N 313 40230 293 40230 {lab=out_cas_int_b8}
C {./lab_pin.sym} 293 40230 0 0 {name=l2137_3 lab=out_cas_int_b8}
N 497 40170 517 40170 {lab=VDD}
C {./lab_pin.sym} 517 40170 0 1 {name=l2137_4 lab=VDD}
N 497 40190 517 40190 {lab=VDD}
C {./lab_pin.sym} 517 40190 0 1 {name=l2137_5 lab=VDD}
N 497 40210 517 40210 {lab=VSS}
C {./lab_pin.sym} 517 40210 0 1 {name=l2137_6 lab=VSS}
N 497 40230 517 40230 {lab=VSS}
C {./lab_pin.sym} 517 40230 0 1 {name=l2137_7 lab=VSS}
C {./dffrnq_1.sym} 810 40200 0 0 {name=Xn_2079}
N 718 40170 698 40170 {lab=n_0136}
C {./lab_pin.sym} 698 40170 0 0 {name=l2138_0 lab=n_0136}
N 718 40190 698 40190 {lab=net18}
C {./lab_pin.sym} 698 40190 0 0 {name=l2138_1 lab=net18}
N 718 40210 698 40210 {lab=clknet_3_3__leaf_clk}
C {./lab_pin.sym} 698 40210 0 0 {name=l2138_2 lab=clknet_3_3__leaf_clk}
N 718 40230 698 40230 {lab=out_cas_int_b9}
C {./lab_pin.sym} 698 40230 0 0 {name=l2138_3 lab=out_cas_int_b9}
N 902 40170 922 40170 {lab=VDD}
C {./lab_pin.sym} 922 40170 0 1 {name=l2138_4 lab=VDD}
N 902 40190 922 40190 {lab=VDD}
C {./lab_pin.sym} 922 40190 0 1 {name=l2138_5 lab=VDD}
N 902 40210 922 40210 {lab=VSS}
C {./lab_pin.sym} 922 40210 0 1 {name=l2138_6 lab=VSS}
N 902 40230 922 40230 {lab=VSS}
C {./lab_pin.sym} 922 40230 0 1 {name=l2138_7 lab=VSS}
C {./dffrnq_1.sym} 1215 40200 0 0 {name=Xn_2080}
N 1123 40170 1103 40170 {lab=n_0113}
C {./lab_pin.sym} 1103 40170 0 0 {name=l2139_0 lab=n_0113}
N 1123 40190 1103 40190 {lab=net18}
C {./lab_pin.sym} 1103 40190 0 0 {name=l2139_1 lab=net18}
N 1123 40210 1103 40210 {lab=clknet_3_3__leaf_clk}
C {./lab_pin.sym} 1103 40210 0 0 {name=l2139_2 lab=clknet_3_3__leaf_clk}
N 1123 40230 1103 40230 {lab=out_cas_int_b10}
C {./lab_pin.sym} 1103 40230 0 0 {name=l2139_3 lab=out_cas_int_b10}
N 1307 40170 1327 40170 {lab=VDD}
C {./lab_pin.sym} 1327 40170 0 1 {name=l2139_4 lab=VDD}
N 1307 40190 1327 40190 {lab=VDD}
C {./lab_pin.sym} 1327 40190 0 1 {name=l2139_5 lab=VDD}
N 1307 40210 1327 40210 {lab=VSS}
C {./lab_pin.sym} 1327 40210 0 1 {name=l2139_6 lab=VSS}
N 1307 40230 1327 40230 {lab=VSS}
C {./lab_pin.sym} 1327 40230 0 1 {name=l2139_7 lab=VSS}
C {./dffrnq_1.sym} 1620 40200 0 0 {name=Xn_2081}
N 1528 40170 1508 40170 {lab=n_0114}
C {./lab_pin.sym} 1508 40170 0 0 {name=l2140_0 lab=n_0114}
N 1528 40190 1508 40190 {lab=net18}
C {./lab_pin.sym} 1508 40190 0 0 {name=l2140_1 lab=net18}
N 1528 40210 1508 40210 {lab=clknet_3_3__leaf_clk}
C {./lab_pin.sym} 1508 40210 0 0 {name=l2140_2 lab=clknet_3_3__leaf_clk}
N 1528 40230 1508 40230 {lab=out_cas_int_b11}
C {./lab_pin.sym} 1508 40230 0 0 {name=l2140_3 lab=out_cas_int_b11}
N 1712 40170 1732 40170 {lab=VDD}
C {./lab_pin.sym} 1732 40170 0 1 {name=l2140_4 lab=VDD}
N 1712 40190 1732 40190 {lab=VDD}
C {./lab_pin.sym} 1732 40190 0 1 {name=l2140_5 lab=VDD}
N 1712 40210 1732 40210 {lab=VSS}
C {./lab_pin.sym} 1732 40210 0 1 {name=l2140_6 lab=VSS}
N 1712 40230 1732 40230 {lab=VSS}
C {./lab_pin.sym} 1732 40230 0 1 {name=l2140_7 lab=VSS}
C {./dffrnq_1.sym} 2025 40200 0 0 {name=Xn_2082}
N 1933 40170 1913 40170 {lab=n_0115}
C {./lab_pin.sym} 1913 40170 0 0 {name=l2141_0 lab=n_0115}
N 1933 40190 1913 40190 {lab=net18}
C {./lab_pin.sym} 1913 40190 0 0 {name=l2141_1 lab=net18}
N 1933 40210 1913 40210 {lab=clknet_3_3__leaf_clk}
C {./lab_pin.sym} 1913 40210 0 0 {name=l2141_2 lab=clknet_3_3__leaf_clk}
N 1933 40230 1913 40230 {lab=out_cas_int_b12}
C {./lab_pin.sym} 1913 40230 0 0 {name=l2141_3 lab=out_cas_int_b12}
N 2117 40170 2137 40170 {lab=VDD}
C {./lab_pin.sym} 2137 40170 0 1 {name=l2141_4 lab=VDD}
N 2117 40190 2137 40190 {lab=VDD}
C {./lab_pin.sym} 2137 40190 0 1 {name=l2141_5 lab=VDD}
N 2117 40210 2137 40210 {lab=VSS}
C {./lab_pin.sym} 2137 40210 0 1 {name=l2141_6 lab=VSS}
N 2117 40230 2137 40230 {lab=VSS}
C {./lab_pin.sym} 2137 40230 0 1 {name=l2141_7 lab=VSS}
C {./dffrnq_1.sym} 2430 40200 0 0 {name=Xn_2083}
N 2338 40170 2318 40170 {lab=n_0116}
C {./lab_pin.sym} 2318 40170 0 0 {name=l2142_0 lab=n_0116}
N 2338 40190 2318 40190 {lab=net18}
C {./lab_pin.sym} 2318 40190 0 0 {name=l2142_1 lab=net18}
N 2338 40210 2318 40210 {lab=clknet_3_6__leaf_clk}
C {./lab_pin.sym} 2318 40210 0 0 {name=l2142_2 lab=clknet_3_6__leaf_clk}
N 2338 40230 2318 40230 {lab=out_cas_int_b13}
C {./lab_pin.sym} 2318 40230 0 0 {name=l2142_3 lab=out_cas_int_b13}
N 2522 40170 2542 40170 {lab=VDD}
C {./lab_pin.sym} 2542 40170 0 1 {name=l2142_4 lab=VDD}
N 2522 40190 2542 40190 {lab=VDD}
C {./lab_pin.sym} 2542 40190 0 1 {name=l2142_5 lab=VDD}
N 2522 40210 2542 40210 {lab=VSS}
C {./lab_pin.sym} 2542 40210 0 1 {name=l2142_6 lab=VSS}
N 2522 40230 2542 40230 {lab=VSS}
C {./lab_pin.sym} 2542 40230 0 1 {name=l2142_7 lab=VSS}
C {./dffrnq_1.sym} 2835 40200 0 0 {name=Xn_2084}
N 2743 40170 2723 40170 {lab=n_0117}
C {./lab_pin.sym} 2723 40170 0 0 {name=l2143_0 lab=n_0117}
N 2743 40190 2723 40190 {lab=net18}
C {./lab_pin.sym} 2723 40190 0 0 {name=l2143_1 lab=net18}
N 2743 40210 2723 40210 {lab=clknet_3_6__leaf_clk}
C {./lab_pin.sym} 2723 40210 0 0 {name=l2143_2 lab=clknet_3_6__leaf_clk}
N 2743 40230 2723 40230 {lab=out_cas_int_b14}
C {./lab_pin.sym} 2723 40230 0 0 {name=l2143_3 lab=out_cas_int_b14}
N 2927 40170 2947 40170 {lab=VDD}
C {./lab_pin.sym} 2947 40170 0 1 {name=l2143_4 lab=VDD}
N 2927 40190 2947 40190 {lab=VDD}
C {./lab_pin.sym} 2947 40190 0 1 {name=l2143_5 lab=VDD}
N 2927 40210 2947 40210 {lab=VSS}
C {./lab_pin.sym} 2947 40210 0 1 {name=l2143_6 lab=VSS}
N 2927 40230 2947 40230 {lab=VSS}
C {./lab_pin.sym} 2947 40230 0 1 {name=l2143_7 lab=VSS}
C {./dffrnq_1.sym} 3240 40200 0 0 {name=Xn_2085}
N 3148 40170 3128 40170 {lab=n_0118}
C {./lab_pin.sym} 3128 40170 0 0 {name=l2144_0 lab=n_0118}
N 3148 40190 3128 40190 {lab=net18}
C {./lab_pin.sym} 3128 40190 0 0 {name=l2144_1 lab=net18}
N 3148 40210 3128 40210 {lab=clknet_3_6__leaf_clk}
C {./lab_pin.sym} 3128 40210 0 0 {name=l2144_2 lab=clknet_3_6__leaf_clk}
N 3148 40230 3128 40230 {lab=out_cas_int_b15}
C {./lab_pin.sym} 3128 40230 0 0 {name=l2144_3 lab=out_cas_int_b15}
N 3332 40170 3352 40170 {lab=VDD}
C {./lab_pin.sym} 3352 40170 0 1 {name=l2144_4 lab=VDD}
N 3332 40190 3352 40190 {lab=VDD}
C {./lab_pin.sym} 3352 40190 0 1 {name=l2144_5 lab=VDD}
N 3332 40210 3352 40210 {lab=VSS}
C {./lab_pin.sym} 3352 40210 0 1 {name=l2144_6 lab=VSS}
N 3332 40230 3352 40230 {lab=VSS}
C {./lab_pin.sym} 3352 40230 0 1 {name=l2144_7 lab=VSS}
C {./dffrnq_1.sym} 3645 40200 0 0 {name=Xn_2086}
N 3553 40170 3533 40170 {lab=n_0119}
C {./lab_pin.sym} 3533 40170 0 0 {name=l2145_0 lab=n_0119}
N 3553 40190 3533 40190 {lab=net18}
C {./lab_pin.sym} 3533 40190 0 0 {name=l2145_1 lab=net18}
N 3553 40210 3533 40210 {lab=clknet_3_6__leaf_clk}
C {./lab_pin.sym} 3533 40210 0 0 {name=l2145_2 lab=clknet_3_6__leaf_clk}
N 3553 40230 3533 40230 {lab=out_cas_int_b16}
C {./lab_pin.sym} 3533 40230 0 0 {name=l2145_3 lab=out_cas_int_b16}
N 3737 40170 3757 40170 {lab=VDD}
C {./lab_pin.sym} 3757 40170 0 1 {name=l2145_4 lab=VDD}
N 3737 40190 3757 40190 {lab=VDD}
C {./lab_pin.sym} 3757 40190 0 1 {name=l2145_5 lab=VDD}
N 3737 40210 3757 40210 {lab=VSS}
C {./lab_pin.sym} 3757 40210 0 1 {name=l2145_6 lab=VSS}
N 3737 40230 3757 40230 {lab=VSS}
C {./lab_pin.sym} 3757 40230 0 1 {name=l2145_7 lab=VSS}
C {./dffrnq_1.sym} 4050 40200 0 0 {name=Xn_2087}
N 3958 40170 3938 40170 {lab=n_0120}
C {./lab_pin.sym} 3938 40170 0 0 {name=l2146_0 lab=n_0120}
N 3958 40190 3938 40190 {lab=net18}
C {./lab_pin.sym} 3938 40190 0 0 {name=l2146_1 lab=net18}
N 3958 40210 3938 40210 {lab=clknet_3_7__leaf_clk}
C {./lab_pin.sym} 3938 40210 0 0 {name=l2146_2 lab=clknet_3_7__leaf_clk}
N 3958 40230 3938 40230 {lab=out_cas_int_b17}
C {./lab_pin.sym} 3938 40230 0 0 {name=l2146_3 lab=out_cas_int_b17}
N 4142 40170 4162 40170 {lab=VDD}
C {./lab_pin.sym} 4162 40170 0 1 {name=l2146_4 lab=VDD}
N 4142 40190 4162 40190 {lab=VDD}
C {./lab_pin.sym} 4162 40190 0 1 {name=l2146_5 lab=VDD}
N 4142 40210 4162 40210 {lab=VSS}
C {./lab_pin.sym} 4162 40210 0 1 {name=l2146_6 lab=VSS}
N 4142 40230 4162 40230 {lab=VSS}
C {./lab_pin.sym} 4162 40230 0 1 {name=l2146_7 lab=VSS}
C {./dffrnq_1.sym} 4455 40200 0 0 {name=Xn_2088}
N 4363 40170 4343 40170 {lab=n_0121}
C {./lab_pin.sym} 4343 40170 0 0 {name=l2147_0 lab=n_0121}
N 4363 40190 4343 40190 {lab=net18}
C {./lab_pin.sym} 4343 40190 0 0 {name=l2147_1 lab=net18}
N 4363 40210 4343 40210 {lab=clknet_3_7__leaf_clk}
C {./lab_pin.sym} 4343 40210 0 0 {name=l2147_2 lab=clknet_3_7__leaf_clk}
N 4363 40230 4343 40230 {lab=out_cas_int_b18}
C {./lab_pin.sym} 4343 40230 0 0 {name=l2147_3 lab=out_cas_int_b18}
N 4547 40170 4567 40170 {lab=VDD}
C {./lab_pin.sym} 4567 40170 0 1 {name=l2147_4 lab=VDD}
N 4547 40190 4567 40190 {lab=VDD}
C {./lab_pin.sym} 4567 40190 0 1 {name=l2147_5 lab=VDD}
N 4547 40210 4567 40210 {lab=VSS}
C {./lab_pin.sym} 4567 40210 0 1 {name=l2147_6 lab=VSS}
N 4547 40230 4567 40230 {lab=VSS}
C {./lab_pin.sym} 4567 40230 0 1 {name=l2147_7 lab=VSS}
C {./dffrnq_1.sym} 0 40425 0 0 {name=Xn_2089}
N -92 40395 -112 40395 {lab=n_0122}
C {./lab_pin.sym} -112 40395 0 0 {name=l2148_0 lab=n_0122}
N -92 40415 -112 40415 {lab=net18}
C {./lab_pin.sym} -112 40415 0 0 {name=l2148_1 lab=net18}
N -92 40435 -112 40435 {lab=clknet_3_7__leaf_clk}
C {./lab_pin.sym} -112 40435 0 0 {name=l2148_2 lab=clknet_3_7__leaf_clk}
N -92 40455 -112 40455 {lab=out_cas_int_b19}
C {./lab_pin.sym} -112 40455 0 0 {name=l2148_3 lab=out_cas_int_b19}
N 92 40395 112 40395 {lab=VDD}
C {./lab_pin.sym} 112 40395 0 1 {name=l2148_4 lab=VDD}
N 92 40415 112 40415 {lab=VDD}
C {./lab_pin.sym} 112 40415 0 1 {name=l2148_5 lab=VDD}
N 92 40435 112 40435 {lab=VSS}
C {./lab_pin.sym} 112 40435 0 1 {name=l2148_6 lab=VSS}
N 92 40455 112 40455 {lab=VSS}
C {./lab_pin.sym} 112 40455 0 1 {name=l2148_7 lab=VSS}
C {./dffrnq_1.sym} 405 40425 0 0 {name=Xn_2090}
N 313 40395 293 40395 {lab=n_0124}
C {./lab_pin.sym} 293 40395 0 0 {name=l2149_0 lab=n_0124}
N 313 40415 293 40415 {lab=net18}
C {./lab_pin.sym} 293 40415 0 0 {name=l2149_1 lab=net18}
N 313 40435 293 40435 {lab=clknet_3_7__leaf_clk}
C {./lab_pin.sym} 293 40435 0 0 {name=l2149_2 lab=clknet_3_7__leaf_clk}
N 313 40455 293 40455 {lab=out_cas_int_b20}
C {./lab_pin.sym} 293 40455 0 0 {name=l2149_3 lab=out_cas_int_b20}
N 497 40395 517 40395 {lab=VDD}
C {./lab_pin.sym} 517 40395 0 1 {name=l2149_4 lab=VDD}
N 497 40415 517 40415 {lab=VDD}
C {./lab_pin.sym} 517 40415 0 1 {name=l2149_5 lab=VDD}
N 497 40435 517 40435 {lab=VSS}
C {./lab_pin.sym} 517 40435 0 1 {name=l2149_6 lab=VSS}
N 497 40455 517 40455 {lab=VSS}
C {./lab_pin.sym} 517 40455 0 1 {name=l2149_7 lab=VSS}
C {./dffrnq_1.sym} 810 40425 0 0 {name=Xn_2091}
N 718 40395 698 40395 {lab=n_0125}
C {./lab_pin.sym} 698 40395 0 0 {name=l2150_0 lab=n_0125}
N 718 40415 698 40415 {lab=net18}
C {./lab_pin.sym} 698 40415 0 0 {name=l2150_1 lab=net18}
N 718 40435 698 40435 {lab=clknet_3_7__leaf_clk}
C {./lab_pin.sym} 698 40435 0 0 {name=l2150_2 lab=clknet_3_7__leaf_clk}
N 718 40455 698 40455 {lab=out_cas_int_b21}
C {./lab_pin.sym} 698 40455 0 0 {name=l2150_3 lab=out_cas_int_b21}
N 902 40395 922 40395 {lab=VDD}
C {./lab_pin.sym} 922 40395 0 1 {name=l2150_4 lab=VDD}
N 902 40415 922 40415 {lab=VDD}
C {./lab_pin.sym} 922 40415 0 1 {name=l2150_5 lab=VDD}
N 902 40435 922 40435 {lab=VSS}
C {./lab_pin.sym} 922 40435 0 1 {name=l2150_6 lab=VSS}
N 902 40455 922 40455 {lab=VSS}
C {./lab_pin.sym} 922 40455 0 1 {name=l2150_7 lab=VSS}
C {./dffrnq_1.sym} 1215 40425 0 0 {name=Xn_2092}
N 1123 40395 1103 40395 {lab=n_0126}
C {./lab_pin.sym} 1103 40395 0 0 {name=l2151_0 lab=n_0126}
N 1123 40415 1103 40415 {lab=net18}
C {./lab_pin.sym} 1103 40415 0 0 {name=l2151_1 lab=net18}
N 1123 40435 1103 40435 {lab=clknet_3_7__leaf_clk}
C {./lab_pin.sym} 1103 40435 0 0 {name=l2151_2 lab=clknet_3_7__leaf_clk}
N 1123 40455 1103 40455 {lab=out_cas_int_b22}
C {./lab_pin.sym} 1103 40455 0 0 {name=l2151_3 lab=out_cas_int_b22}
N 1307 40395 1327 40395 {lab=VDD}
C {./lab_pin.sym} 1327 40395 0 1 {name=l2151_4 lab=VDD}
N 1307 40415 1327 40415 {lab=VDD}
C {./lab_pin.sym} 1327 40415 0 1 {name=l2151_5 lab=VDD}
N 1307 40435 1327 40435 {lab=VSS}
C {./lab_pin.sym} 1327 40435 0 1 {name=l2151_6 lab=VSS}
N 1307 40455 1327 40455 {lab=VSS}
C {./lab_pin.sym} 1327 40455 0 1 {name=l2151_7 lab=VSS}
C {./dffrnq_1.sym} 1620 40425 0 0 {name=Xn_2093}
N 1528 40395 1508 40395 {lab=n_0127}
C {./lab_pin.sym} 1508 40395 0 0 {name=l2152_0 lab=n_0127}
N 1528 40415 1508 40415 {lab=net18}
C {./lab_pin.sym} 1508 40415 0 0 {name=l2152_1 lab=net18}
N 1528 40435 1508 40435 {lab=clknet_3_7__leaf_clk}
C {./lab_pin.sym} 1508 40435 0 0 {name=l2152_2 lab=clknet_3_7__leaf_clk}
N 1528 40455 1508 40455 {lab=out_cas_int_b23}
C {./lab_pin.sym} 1508 40455 0 0 {name=l2152_3 lab=out_cas_int_b23}
N 1712 40395 1732 40395 {lab=VDD}
C {./lab_pin.sym} 1732 40395 0 1 {name=l2152_4 lab=VDD}
N 1712 40415 1732 40415 {lab=VDD}
C {./lab_pin.sym} 1732 40415 0 1 {name=l2152_5 lab=VDD}
N 1712 40435 1732 40435 {lab=VSS}
C {./lab_pin.sym} 1732 40435 0 1 {name=l2152_6 lab=VSS}
N 1712 40455 1732 40455 {lab=VSS}
C {./lab_pin.sym} 1732 40455 0 1 {name=l2152_7 lab=VSS}
C {./dffrnq_1.sym} 2025 40425 0 0 {name=Xn_2094}
N 1933 40395 1913 40395 {lab=n_0128}
C {./lab_pin.sym} 1913 40395 0 0 {name=l2153_0 lab=n_0128}
N 1933 40415 1913 40415 {lab=net18}
C {./lab_pin.sym} 1913 40415 0 0 {name=l2153_1 lab=net18}
N 1933 40435 1913 40435 {lab=clknet_3_7__leaf_clk}
C {./lab_pin.sym} 1913 40435 0 0 {name=l2153_2 lab=clknet_3_7__leaf_clk}
N 1933 40455 1913 40455 {lab=out_cas_int_b24}
C {./lab_pin.sym} 1913 40455 0 0 {name=l2153_3 lab=out_cas_int_b24}
N 2117 40395 2137 40395 {lab=VDD}
C {./lab_pin.sym} 2137 40395 0 1 {name=l2153_4 lab=VDD}
N 2117 40415 2137 40415 {lab=VDD}
C {./lab_pin.sym} 2137 40415 0 1 {name=l2153_5 lab=VDD}
N 2117 40435 2137 40435 {lab=VSS}
C {./lab_pin.sym} 2137 40435 0 1 {name=l2153_6 lab=VSS}
N 2117 40455 2137 40455 {lab=VSS}
C {./lab_pin.sym} 2137 40455 0 1 {name=l2153_7 lab=VSS}
C {./dffrnq_1.sym} 2430 40425 0 0 {name=Xn_2095}
N 2338 40395 2318 40395 {lab=n_0087}
C {./lab_pin.sym} 2318 40395 0 0 {name=l2154_0 lab=n_0087}
N 2338 40415 2318 40415 {lab=net17}
C {./lab_pin.sym} 2318 40415 0 0 {name=l2154_1 lab=net17}
N 2338 40435 2318 40435 {lab=clknet_3_2__leaf_clk}
C {./lab_pin.sym} 2318 40435 0 0 {name=l2154_2 lab=clknet_3_2__leaf_clk}
N 2338 40455 2318 40455 {lab=u_cas_int_out_int2_b0}
C {./lab_pin.sym} 2318 40455 0 0 {name=l2154_3 lab=u_cas_int_out_int2_b0}
N 2522 40395 2542 40395 {lab=VDD}
C {./lab_pin.sym} 2542 40395 0 1 {name=l2154_4 lab=VDD}
N 2522 40415 2542 40415 {lab=VDD}
C {./lab_pin.sym} 2542 40415 0 1 {name=l2154_5 lab=VDD}
N 2522 40435 2542 40435 {lab=VSS}
C {./lab_pin.sym} 2542 40435 0 1 {name=l2154_6 lab=VSS}
N 2522 40455 2542 40455 {lab=VSS}
C {./lab_pin.sym} 2542 40455 0 1 {name=l2154_7 lab=VSS}
C {./dffrnq_1.sym} 2835 40425 0 0 {name=Xn_2096}
N 2743 40395 2723 40395 {lab=n_0098}
C {./lab_pin.sym} 2723 40395 0 0 {name=l2155_0 lab=n_0098}
N 2743 40415 2723 40415 {lab=net17}
C {./lab_pin.sym} 2723 40415 0 0 {name=l2155_1 lab=net17}
N 2743 40435 2723 40435 {lab=clknet_3_2__leaf_clk}
C {./lab_pin.sym} 2723 40435 0 0 {name=l2155_2 lab=clknet_3_2__leaf_clk}
N 2743 40455 2723 40455 {lab=u_cas_int_out_int2_b1}
C {./lab_pin.sym} 2723 40455 0 0 {name=l2155_3 lab=u_cas_int_out_int2_b1}
N 2927 40395 2947 40395 {lab=VDD}
C {./lab_pin.sym} 2947 40395 0 1 {name=l2155_4 lab=VDD}
N 2927 40415 2947 40415 {lab=VDD}
C {./lab_pin.sym} 2947 40415 0 1 {name=l2155_5 lab=VDD}
N 2927 40435 2947 40435 {lab=VSS}
C {./lab_pin.sym} 2947 40435 0 1 {name=l2155_6 lab=VSS}
N 2927 40455 2947 40455 {lab=VSS}
C {./lab_pin.sym} 2947 40455 0 1 {name=l2155_7 lab=VSS}
C {./dffrnq_1.sym} 3240 40425 0 0 {name=Xn_2097}
N 3148 40395 3128 40395 {lab=n_0104}
C {./lab_pin.sym} 3128 40395 0 0 {name=l2156_0 lab=n_0104}
N 3148 40415 3128 40415 {lab=net21}
C {./lab_pin.sym} 3128 40415 0 0 {name=l2156_1 lab=net21}
N 3148 40435 3128 40435 {lab=clknet_3_2__leaf_clk}
C {./lab_pin.sym} 3128 40435 0 0 {name=l2156_2 lab=clknet_3_2__leaf_clk}
N 3148 40455 3128 40455 {lab=u_cas_int_out_int2_b2}
C {./lab_pin.sym} 3128 40455 0 0 {name=l2156_3 lab=u_cas_int_out_int2_b2}
N 3332 40395 3352 40395 {lab=VDD}
C {./lab_pin.sym} 3352 40395 0 1 {name=l2156_4 lab=VDD}
N 3332 40415 3352 40415 {lab=VDD}
C {./lab_pin.sym} 3352 40415 0 1 {name=l2156_5 lab=VDD}
N 3332 40435 3352 40435 {lab=VSS}
C {./lab_pin.sym} 3352 40435 0 1 {name=l2156_6 lab=VSS}
N 3332 40455 3352 40455 {lab=VSS}
C {./lab_pin.sym} 3352 40455 0 1 {name=l2156_7 lab=VSS}
C {./dffrnq_1.sym} 3645 40425 0 0 {name=Xn_2098}
N 3553 40395 3533 40395 {lab=n_0105}
C {./lab_pin.sym} 3533 40395 0 0 {name=l2157_0 lab=n_0105}
N 3553 40415 3533 40415 {lab=net21}
C {./lab_pin.sym} 3533 40415 0 0 {name=l2157_1 lab=net21}
N 3553 40435 3533 40435 {lab=clknet_3_2__leaf_clk}
C {./lab_pin.sym} 3533 40435 0 0 {name=l2157_2 lab=clknet_3_2__leaf_clk}
N 3553 40455 3533 40455 {lab=u_cas_int_out_int2_b3}
C {./lab_pin.sym} 3533 40455 0 0 {name=l2157_3 lab=u_cas_int_out_int2_b3}
N 3737 40395 3757 40395 {lab=VDD}
C {./lab_pin.sym} 3757 40395 0 1 {name=l2157_4 lab=VDD}
N 3737 40415 3757 40415 {lab=VDD}
C {./lab_pin.sym} 3757 40415 0 1 {name=l2157_5 lab=VDD}
N 3737 40435 3757 40435 {lab=VSS}
C {./lab_pin.sym} 3757 40435 0 1 {name=l2157_6 lab=VSS}
N 3737 40455 3757 40455 {lab=VSS}
C {./lab_pin.sym} 3757 40455 0 1 {name=l2157_7 lab=VSS}
C {./dffrnq_1.sym} 4050 40425 0 0 {name=Xn_2099}
N 3958 40395 3938 40395 {lab=n_0106}
C {./lab_pin.sym} 3938 40395 0 0 {name=l2158_0 lab=n_0106}
N 3958 40415 3938 40415 {lab=net21}
C {./lab_pin.sym} 3938 40415 0 0 {name=l2158_1 lab=net21}
N 3958 40435 3938 40435 {lab=clknet_3_2__leaf_clk}
C {./lab_pin.sym} 3938 40435 0 0 {name=l2158_2 lab=clknet_3_2__leaf_clk}
N 3958 40455 3938 40455 {lab=u_cas_int_out_int2_b4}
C {./lab_pin.sym} 3938 40455 0 0 {name=l2158_3 lab=u_cas_int_out_int2_b4}
N 4142 40395 4162 40395 {lab=VDD}
C {./lab_pin.sym} 4162 40395 0 1 {name=l2158_4 lab=VDD}
N 4142 40415 4162 40415 {lab=VDD}
C {./lab_pin.sym} 4162 40415 0 1 {name=l2158_5 lab=VDD}
N 4142 40435 4162 40435 {lab=VSS}
C {./lab_pin.sym} 4162 40435 0 1 {name=l2158_6 lab=VSS}
N 4142 40455 4162 40455 {lab=VSS}
C {./lab_pin.sym} 4162 40455 0 1 {name=l2158_7 lab=VSS}
C {./dffrnq_1.sym} 4455 40425 0 0 {name=Xn_2100}
N 4363 40395 4343 40395 {lab=n_0107}
C {./lab_pin.sym} 4343 40395 0 0 {name=l2159_0 lab=n_0107}
N 4363 40415 4343 40415 {lab=net21}
C {./lab_pin.sym} 4343 40415 0 0 {name=l2159_1 lab=net21}
N 4363 40435 4343 40435 {lab=clknet_3_2__leaf_clk}
C {./lab_pin.sym} 4343 40435 0 0 {name=l2159_2 lab=clknet_3_2__leaf_clk}
N 4363 40455 4343 40455 {lab=u_cas_int_out_int2_b5}
C {./lab_pin.sym} 4343 40455 0 0 {name=l2159_3 lab=u_cas_int_out_int2_b5}
N 4547 40395 4567 40395 {lab=VDD}
C {./lab_pin.sym} 4567 40395 0 1 {name=l2159_4 lab=VDD}
N 4547 40415 4567 40415 {lab=VDD}
C {./lab_pin.sym} 4567 40415 0 1 {name=l2159_5 lab=VDD}
N 4547 40435 4567 40435 {lab=VSS}
C {./lab_pin.sym} 4567 40435 0 1 {name=l2159_6 lab=VSS}
N 4547 40455 4567 40455 {lab=VSS}
C {./lab_pin.sym} 4567 40455 0 1 {name=l2159_7 lab=VSS}
C {./dffrnq_1.sym} 0 40650 0 0 {name=Xn_2101}
N -92 40620 -112 40620 {lab=n_0108}
C {./lab_pin.sym} -112 40620 0 0 {name=l2160_0 lab=n_0108}
N -92 40640 -112 40640 {lab=net21}
C {./lab_pin.sym} -112 40640 0 0 {name=l2160_1 lab=net21}
N -92 40660 -112 40660 {lab=clknet_3_3__leaf_clk}
C {./lab_pin.sym} -112 40660 0 0 {name=l2160_2 lab=clknet_3_3__leaf_clk}
N -92 40680 -112 40680 {lab=u_cas_int_out_int2_b6}
C {./lab_pin.sym} -112 40680 0 0 {name=l2160_3 lab=u_cas_int_out_int2_b6}
N 92 40620 112 40620 {lab=VDD}
C {./lab_pin.sym} 112 40620 0 1 {name=l2160_4 lab=VDD}
N 92 40640 112 40640 {lab=VDD}
C {./lab_pin.sym} 112 40640 0 1 {name=l2160_5 lab=VDD}
N 92 40660 112 40660 {lab=VSS}
C {./lab_pin.sym} 112 40660 0 1 {name=l2160_6 lab=VSS}
N 92 40680 112 40680 {lab=VSS}
C {./lab_pin.sym} 112 40680 0 1 {name=l2160_7 lab=VSS}
C {./dffrnq_1.sym} 405 40650 0 0 {name=Xn_2102}
N 313 40620 293 40620 {lab=n_0109}
C {./lab_pin.sym} 293 40620 0 0 {name=l2161_0 lab=n_0109}
N 313 40640 293 40640 {lab=net21}
C {./lab_pin.sym} 293 40640 0 0 {name=l2161_1 lab=net21}
N 313 40660 293 40660 {lab=clknet_3_3__leaf_clk}
C {./lab_pin.sym} 293 40660 0 0 {name=l2161_2 lab=clknet_3_3__leaf_clk}
N 313 40680 293 40680 {lab=u_cas_int_out_int2_b7}
C {./lab_pin.sym} 293 40680 0 0 {name=l2161_3 lab=u_cas_int_out_int2_b7}
N 497 40620 517 40620 {lab=VDD}
C {./lab_pin.sym} 517 40620 0 1 {name=l2161_4 lab=VDD}
N 497 40640 517 40640 {lab=VDD}
C {./lab_pin.sym} 517 40640 0 1 {name=l2161_5 lab=VDD}
N 497 40660 517 40660 {lab=VSS}
C {./lab_pin.sym} 517 40660 0 1 {name=l2161_6 lab=VSS}
N 497 40680 517 40680 {lab=VSS}
C {./lab_pin.sym} 517 40680 0 1 {name=l2161_7 lab=VSS}
C {./dffrnq_1.sym} 810 40650 0 0 {name=Xn_2103}
N 718 40620 698 40620 {lab=n_0110}
C {./lab_pin.sym} 698 40620 0 0 {name=l2162_0 lab=n_0110}
N 718 40640 698 40640 {lab=net21}
C {./lab_pin.sym} 698 40640 0 0 {name=l2162_1 lab=net21}
N 718 40660 698 40660 {lab=clknet_3_1__leaf_clk}
C {./lab_pin.sym} 698 40660 0 0 {name=l2162_2 lab=clknet_3_1__leaf_clk}
N 718 40680 698 40680 {lab=u_cas_int_out_int2_b8}
C {./lab_pin.sym} 698 40680 0 0 {name=l2162_3 lab=u_cas_int_out_int2_b8}
N 902 40620 922 40620 {lab=VDD}
C {./lab_pin.sym} 922 40620 0 1 {name=l2162_4 lab=VDD}
N 902 40640 922 40640 {lab=VDD}
C {./lab_pin.sym} 922 40640 0 1 {name=l2162_5 lab=VDD}
N 902 40660 922 40660 {lab=VSS}
C {./lab_pin.sym} 922 40660 0 1 {name=l2162_6 lab=VSS}
N 902 40680 922 40680 {lab=VSS}
C {./lab_pin.sym} 922 40680 0 1 {name=l2162_7 lab=VSS}
C {./dffrnq_1.sym} 1215 40650 0 0 {name=Xn_2104}
N 1123 40620 1103 40620 {lab=n_0111}
C {./lab_pin.sym} 1103 40620 0 0 {name=l2163_0 lab=n_0111}
N 1123 40640 1103 40640 {lab=net21}
C {./lab_pin.sym} 1103 40640 0 0 {name=l2163_1 lab=net21}
N 1123 40660 1103 40660 {lab=clknet_3_1__leaf_clk}
C {./lab_pin.sym} 1103 40660 0 0 {name=l2163_2 lab=clknet_3_1__leaf_clk}
N 1123 40680 1103 40680 {lab=u_cas_int_out_int2_b9}
C {./lab_pin.sym} 1103 40680 0 0 {name=l2163_3 lab=u_cas_int_out_int2_b9}
N 1307 40620 1327 40620 {lab=VDD}
C {./lab_pin.sym} 1327 40620 0 1 {name=l2163_4 lab=VDD}
N 1307 40640 1327 40640 {lab=VDD}
C {./lab_pin.sym} 1327 40640 0 1 {name=l2163_5 lab=VDD}
N 1307 40660 1327 40660 {lab=VSS}
C {./lab_pin.sym} 1327 40660 0 1 {name=l2163_6 lab=VSS}
N 1307 40680 1327 40680 {lab=VSS}
C {./lab_pin.sym} 1327 40680 0 1 {name=l2163_7 lab=VSS}
C {./dffrnq_1.sym} 1620 40650 0 0 {name=Xn_2105}
N 1528 40620 1508 40620 {lab=n_0088}
C {./lab_pin.sym} 1508 40620 0 0 {name=l2164_0 lab=n_0088}
N 1528 40640 1508 40640 {lab=net21}
C {./lab_pin.sym} 1508 40640 0 0 {name=l2164_1 lab=net21}
N 1528 40660 1508 40660 {lab=clknet_3_1__leaf_clk}
C {./lab_pin.sym} 1508 40660 0 0 {name=l2164_2 lab=clknet_3_1__leaf_clk}
N 1528 40680 1508 40680 {lab=u_cas_int_out_int2_b10}
C {./lab_pin.sym} 1508 40680 0 0 {name=l2164_3 lab=u_cas_int_out_int2_b10}
N 1712 40620 1732 40620 {lab=VDD}
C {./lab_pin.sym} 1732 40620 0 1 {name=l2164_4 lab=VDD}
N 1712 40640 1732 40640 {lab=VDD}
C {./lab_pin.sym} 1732 40640 0 1 {name=l2164_5 lab=VDD}
N 1712 40660 1732 40660 {lab=VSS}
C {./lab_pin.sym} 1732 40660 0 1 {name=l2164_6 lab=VSS}
N 1712 40680 1732 40680 {lab=VSS}
C {./lab_pin.sym} 1732 40680 0 1 {name=l2164_7 lab=VSS}
C {./dffrnq_1.sym} 2025 40650 0 0 {name=Xn_2106}
N 1933 40620 1913 40620 {lab=n_0089}
C {./lab_pin.sym} 1913 40620 0 0 {name=l2165_0 lab=n_0089}
N 1933 40640 1913 40640 {lab=net21}
C {./lab_pin.sym} 1913 40640 0 0 {name=l2165_1 lab=net21}
N 1933 40660 1913 40660 {lab=clknet_3_1__leaf_clk}
C {./lab_pin.sym} 1913 40660 0 0 {name=l2165_2 lab=clknet_3_1__leaf_clk}
N 1933 40680 1913 40680 {lab=u_cas_int_out_int2_b11}
C {./lab_pin.sym} 1913 40680 0 0 {name=l2165_3 lab=u_cas_int_out_int2_b11}
N 2117 40620 2137 40620 {lab=VDD}
C {./lab_pin.sym} 2137 40620 0 1 {name=l2165_4 lab=VDD}
N 2117 40640 2137 40640 {lab=VDD}
C {./lab_pin.sym} 2137 40640 0 1 {name=l2165_5 lab=VDD}
N 2117 40660 2137 40660 {lab=VSS}
C {./lab_pin.sym} 2137 40660 0 1 {name=l2165_6 lab=VSS}
N 2117 40680 2137 40680 {lab=VSS}
C {./lab_pin.sym} 2137 40680 0 1 {name=l2165_7 lab=VSS}
C {./dffrnq_1.sym} 2430 40650 0 0 {name=Xn_2107}
N 2338 40620 2318 40620 {lab=n_0090}
C {./lab_pin.sym} 2318 40620 0 0 {name=l2166_0 lab=n_0090}
N 2338 40640 2318 40640 {lab=net21}
C {./lab_pin.sym} 2318 40640 0 0 {name=l2166_1 lab=net21}
N 2338 40660 2318 40660 {lab=clknet_3_1__leaf_clk}
C {./lab_pin.sym} 2318 40660 0 0 {name=l2166_2 lab=clknet_3_1__leaf_clk}
N 2338 40680 2318 40680 {lab=u_cas_int_out_int2_b12}
C {./lab_pin.sym} 2318 40680 0 0 {name=l2166_3 lab=u_cas_int_out_int2_b12}
N 2522 40620 2542 40620 {lab=VDD}
C {./lab_pin.sym} 2542 40620 0 1 {name=l2166_4 lab=VDD}
N 2522 40640 2542 40640 {lab=VDD}
C {./lab_pin.sym} 2542 40640 0 1 {name=l2166_5 lab=VDD}
N 2522 40660 2542 40660 {lab=VSS}
C {./lab_pin.sym} 2542 40660 0 1 {name=l2166_6 lab=VSS}
N 2522 40680 2542 40680 {lab=VSS}
C {./lab_pin.sym} 2542 40680 0 1 {name=l2166_7 lab=VSS}
C {./dffrnq_1.sym} 2835 40650 0 0 {name=Xn_2108}
N 2743 40620 2723 40620 {lab=n_0091}
C {./lab_pin.sym} 2723 40620 0 0 {name=l2167_0 lab=n_0091}
N 2743 40640 2723 40640 {lab=net21}
C {./lab_pin.sym} 2723 40640 0 0 {name=l2167_1 lab=net21}
N 2743 40660 2723 40660 {lab=clknet_3_6__leaf_clk}
C {./lab_pin.sym} 2723 40660 0 0 {name=l2167_2 lab=clknet_3_6__leaf_clk}
N 2743 40680 2723 40680 {lab=u_cas_int_out_int2_b13}
C {./lab_pin.sym} 2723 40680 0 0 {name=l2167_3 lab=u_cas_int_out_int2_b13}
N 2927 40620 2947 40620 {lab=VDD}
C {./lab_pin.sym} 2947 40620 0 1 {name=l2167_4 lab=VDD}
N 2927 40640 2947 40640 {lab=VDD}
C {./lab_pin.sym} 2947 40640 0 1 {name=l2167_5 lab=VDD}
N 2927 40660 2947 40660 {lab=VSS}
C {./lab_pin.sym} 2947 40660 0 1 {name=l2167_6 lab=VSS}
N 2927 40680 2947 40680 {lab=VSS}
C {./lab_pin.sym} 2947 40680 0 1 {name=l2167_7 lab=VSS}
C {./dffrnq_1.sym} 3240 40650 0 0 {name=Xn_2109}
N 3148 40620 3128 40620 {lab=n_0092}
C {./lab_pin.sym} 3128 40620 0 0 {name=l2168_0 lab=n_0092}
N 3148 40640 3128 40640 {lab=net21}
C {./lab_pin.sym} 3128 40640 0 0 {name=l2168_1 lab=net21}
N 3148 40660 3128 40660 {lab=clknet_3_4__leaf_clk}
C {./lab_pin.sym} 3128 40660 0 0 {name=l2168_2 lab=clknet_3_4__leaf_clk}
N 3148 40680 3128 40680 {lab=u_cas_int_out_int2_b14}
C {./lab_pin.sym} 3128 40680 0 0 {name=l2168_3 lab=u_cas_int_out_int2_b14}
N 3332 40620 3352 40620 {lab=VDD}
C {./lab_pin.sym} 3352 40620 0 1 {name=l2168_4 lab=VDD}
N 3332 40640 3352 40640 {lab=VDD}
C {./lab_pin.sym} 3352 40640 0 1 {name=l2168_5 lab=VDD}
N 3332 40660 3352 40660 {lab=VSS}
C {./lab_pin.sym} 3352 40660 0 1 {name=l2168_6 lab=VSS}
N 3332 40680 3352 40680 {lab=VSS}
C {./lab_pin.sym} 3352 40680 0 1 {name=l2168_7 lab=VSS}
C {./dffrnq_1.sym} 3645 40650 0 0 {name=Xn_2110}
N 3553 40620 3533 40620 {lab=n_0093}
C {./lab_pin.sym} 3533 40620 0 0 {name=l2169_0 lab=n_0093}
N 3553 40640 3533 40640 {lab=net21}
C {./lab_pin.sym} 3533 40640 0 0 {name=l2169_1 lab=net21}
N 3553 40660 3533 40660 {lab=clknet_3_4__leaf_clk}
C {./lab_pin.sym} 3533 40660 0 0 {name=l2169_2 lab=clknet_3_4__leaf_clk}
N 3553 40680 3533 40680 {lab=u_cas_int_out_int2_b15}
C {./lab_pin.sym} 3533 40680 0 0 {name=l2169_3 lab=u_cas_int_out_int2_b15}
N 3737 40620 3757 40620 {lab=VDD}
C {./lab_pin.sym} 3757 40620 0 1 {name=l2169_4 lab=VDD}
N 3737 40640 3757 40640 {lab=VDD}
C {./lab_pin.sym} 3757 40640 0 1 {name=l2169_5 lab=VDD}
N 3737 40660 3757 40660 {lab=VSS}
C {./lab_pin.sym} 3757 40660 0 1 {name=l2169_6 lab=VSS}
N 3737 40680 3757 40680 {lab=VSS}
C {./lab_pin.sym} 3757 40680 0 1 {name=l2169_7 lab=VSS}
C {./dffrnq_1.sym} 4050 40650 0 0 {name=Xn_2111}
N 3958 40620 3938 40620 {lab=n_0094}
C {./lab_pin.sym} 3938 40620 0 0 {name=l2170_0 lab=n_0094}
N 3958 40640 3938 40640 {lab=net21}
C {./lab_pin.sym} 3938 40640 0 0 {name=l2170_1 lab=net21}
N 3958 40660 3938 40660 {lab=clknet_3_6__leaf_clk}
C {./lab_pin.sym} 3938 40660 0 0 {name=l2170_2 lab=clknet_3_6__leaf_clk}
N 3958 40680 3938 40680 {lab=u_cas_int_out_int2_b16}
C {./lab_pin.sym} 3938 40680 0 0 {name=l2170_3 lab=u_cas_int_out_int2_b16}
N 4142 40620 4162 40620 {lab=VDD}
C {./lab_pin.sym} 4162 40620 0 1 {name=l2170_4 lab=VDD}
N 4142 40640 4162 40640 {lab=VDD}
C {./lab_pin.sym} 4162 40640 0 1 {name=l2170_5 lab=VDD}
N 4142 40660 4162 40660 {lab=VSS}
C {./lab_pin.sym} 4162 40660 0 1 {name=l2170_6 lab=VSS}
N 4142 40680 4162 40680 {lab=VSS}
C {./lab_pin.sym} 4162 40680 0 1 {name=l2170_7 lab=VSS}
C {./dffrnq_1.sym} 4455 40650 0 0 {name=Xn_2112}
N 4363 40620 4343 40620 {lab=n_0095}
C {./lab_pin.sym} 4343 40620 0 0 {name=l2171_0 lab=n_0095}
N 4363 40640 4343 40640 {lab=net21}
C {./lab_pin.sym} 4343 40640 0 0 {name=l2171_1 lab=net21}
N 4363 40660 4343 40660 {lab=clknet_3_4__leaf_clk}
C {./lab_pin.sym} 4343 40660 0 0 {name=l2171_2 lab=clknet_3_4__leaf_clk}
N 4363 40680 4343 40680 {lab=u_cas_int_out_int2_b17}
C {./lab_pin.sym} 4343 40680 0 0 {name=l2171_3 lab=u_cas_int_out_int2_b17}
N 4547 40620 4567 40620 {lab=VDD}
C {./lab_pin.sym} 4567 40620 0 1 {name=l2171_4 lab=VDD}
N 4547 40640 4567 40640 {lab=VDD}
C {./lab_pin.sym} 4567 40640 0 1 {name=l2171_5 lab=VDD}
N 4547 40660 4567 40660 {lab=VSS}
C {./lab_pin.sym} 4567 40660 0 1 {name=l2171_6 lab=VSS}
N 4547 40680 4567 40680 {lab=VSS}
C {./lab_pin.sym} 4567 40680 0 1 {name=l2171_7 lab=VSS}
C {./dffrnq_1.sym} 0 40875 0 0 {name=Xn_2113}
N -92 40845 -112 40845 {lab=n_0096}
C {./lab_pin.sym} -112 40845 0 0 {name=l2172_0 lab=n_0096}
N -92 40865 -112 40865 {lab=net21}
C {./lab_pin.sym} -112 40865 0 0 {name=l2172_1 lab=net21}
N -92 40885 -112 40885 {lab=clknet_3_6__leaf_clk}
C {./lab_pin.sym} -112 40885 0 0 {name=l2172_2 lab=clknet_3_6__leaf_clk}
N -92 40905 -112 40905 {lab=u_cas_int_out_int2_b18}
C {./lab_pin.sym} -112 40905 0 0 {name=l2172_3 lab=u_cas_int_out_int2_b18}
N 92 40845 112 40845 {lab=VDD}
C {./lab_pin.sym} 112 40845 0 1 {name=l2172_4 lab=VDD}
N 92 40865 112 40865 {lab=VDD}
C {./lab_pin.sym} 112 40865 0 1 {name=l2172_5 lab=VDD}
N 92 40885 112 40885 {lab=VSS}
C {./lab_pin.sym} 112 40885 0 1 {name=l2172_6 lab=VSS}
N 92 40905 112 40905 {lab=VSS}
C {./lab_pin.sym} 112 40905 0 1 {name=l2172_7 lab=VSS}
C {./dffrnq_1.sym} 405 40875 0 0 {name=Xn_2114}
N 313 40845 293 40845 {lab=n_0097}
C {./lab_pin.sym} 293 40845 0 0 {name=l2173_0 lab=n_0097}
N 313 40865 293 40865 {lab=net21}
C {./lab_pin.sym} 293 40865 0 0 {name=l2173_1 lab=net21}
N 313 40885 293 40885 {lab=clknet_3_5__leaf_clk}
C {./lab_pin.sym} 293 40885 0 0 {name=l2173_2 lab=clknet_3_5__leaf_clk}
N 313 40905 293 40905 {lab=u_cas_int_out_int2_b19}
C {./lab_pin.sym} 293 40905 0 0 {name=l2173_3 lab=u_cas_int_out_int2_b19}
N 497 40845 517 40845 {lab=VDD}
C {./lab_pin.sym} 517 40845 0 1 {name=l2173_4 lab=VDD}
N 497 40865 517 40865 {lab=VDD}
C {./lab_pin.sym} 517 40865 0 1 {name=l2173_5 lab=VDD}
N 497 40885 517 40885 {lab=VSS}
C {./lab_pin.sym} 517 40885 0 1 {name=l2173_6 lab=VSS}
N 497 40905 517 40905 {lab=VSS}
C {./lab_pin.sym} 517 40905 0 1 {name=l2173_7 lab=VSS}
C {./dffrnq_1.sym} 810 40875 0 0 {name=Xn_2115}
N 718 40845 698 40845 {lab=n_0099}
C {./lab_pin.sym} 698 40845 0 0 {name=l2174_0 lab=n_0099}
N 718 40865 698 40865 {lab=net21}
C {./lab_pin.sym} 698 40865 0 0 {name=l2174_1 lab=net21}
N 718 40885 698 40885 {lab=clknet_3_5__leaf_clk}
C {./lab_pin.sym} 698 40885 0 0 {name=l2174_2 lab=clknet_3_5__leaf_clk}
N 718 40905 698 40905 {lab=u_cas_int_out_int2_b20}
C {./lab_pin.sym} 698 40905 0 0 {name=l2174_3 lab=u_cas_int_out_int2_b20}
N 902 40845 922 40845 {lab=VDD}
C {./lab_pin.sym} 922 40845 0 1 {name=l2174_4 lab=VDD}
N 902 40865 922 40865 {lab=VDD}
C {./lab_pin.sym} 922 40865 0 1 {name=l2174_5 lab=VDD}
N 902 40885 922 40885 {lab=VSS}
C {./lab_pin.sym} 922 40885 0 1 {name=l2174_6 lab=VSS}
N 902 40905 922 40905 {lab=VSS}
C {./lab_pin.sym} 922 40905 0 1 {name=l2174_7 lab=VSS}
C {./dffrnq_1.sym} 1215 40875 0 0 {name=Xn_2116}
N 1123 40845 1103 40845 {lab=n_0100}
C {./lab_pin.sym} 1103 40845 0 0 {name=l2175_0 lab=n_0100}
N 1123 40865 1103 40865 {lab=net21}
C {./lab_pin.sym} 1103 40865 0 0 {name=l2175_1 lab=net21}
N 1123 40885 1103 40885 {lab=clknet_3_5__leaf_clk}
C {./lab_pin.sym} 1103 40885 0 0 {name=l2175_2 lab=clknet_3_5__leaf_clk}
N 1123 40905 1103 40905 {lab=u_cas_int_out_int2_b21}
C {./lab_pin.sym} 1103 40905 0 0 {name=l2175_3 lab=u_cas_int_out_int2_b21}
N 1307 40845 1327 40845 {lab=VDD}
C {./lab_pin.sym} 1327 40845 0 1 {name=l2175_4 lab=VDD}
N 1307 40865 1327 40865 {lab=VDD}
C {./lab_pin.sym} 1327 40865 0 1 {name=l2175_5 lab=VDD}
N 1307 40885 1327 40885 {lab=VSS}
C {./lab_pin.sym} 1327 40885 0 1 {name=l2175_6 lab=VSS}
N 1307 40905 1327 40905 {lab=VSS}
C {./lab_pin.sym} 1327 40905 0 1 {name=l2175_7 lab=VSS}
C {./dffrnq_1.sym} 1620 40875 0 0 {name=Xn_2117}
N 1528 40845 1508 40845 {lab=n_0101}
C {./lab_pin.sym} 1508 40845 0 0 {name=l2176_0 lab=n_0101}
N 1528 40865 1508 40865 {lab=net21}
C {./lab_pin.sym} 1508 40865 0 0 {name=l2176_1 lab=net21}
N 1528 40885 1508 40885 {lab=clknet_3_5__leaf_clk}
C {./lab_pin.sym} 1508 40885 0 0 {name=l2176_2 lab=clknet_3_5__leaf_clk}
N 1528 40905 1508 40905 {lab=u_cas_int_out_int2_b22}
C {./lab_pin.sym} 1508 40905 0 0 {name=l2176_3 lab=u_cas_int_out_int2_b22}
N 1712 40845 1732 40845 {lab=VDD}
C {./lab_pin.sym} 1732 40845 0 1 {name=l2176_4 lab=VDD}
N 1712 40865 1732 40865 {lab=VDD}
C {./lab_pin.sym} 1732 40865 0 1 {name=l2176_5 lab=VDD}
N 1712 40885 1732 40885 {lab=VSS}
C {./lab_pin.sym} 1732 40885 0 1 {name=l2176_6 lab=VSS}
N 1712 40905 1732 40905 {lab=VSS}
C {./lab_pin.sym} 1732 40905 0 1 {name=l2176_7 lab=VSS}
C {./dffrnq_1.sym} 2025 40875 0 0 {name=Xn_2118}
N 1933 40845 1913 40845 {lab=n_0102}
C {./lab_pin.sym} 1913 40845 0 0 {name=l2177_0 lab=n_0102}
N 1933 40865 1913 40865 {lab=net21}
C {./lab_pin.sym} 1913 40865 0 0 {name=l2177_1 lab=net21}
N 1933 40885 1913 40885 {lab=clknet_3_5__leaf_clk}
C {./lab_pin.sym} 1913 40885 0 0 {name=l2177_2 lab=clknet_3_5__leaf_clk}
N 1933 40905 1913 40905 {lab=u_cas_int_out_int2_b23}
C {./lab_pin.sym} 1913 40905 0 0 {name=l2177_3 lab=u_cas_int_out_int2_b23}
N 2117 40845 2137 40845 {lab=VDD}
C {./lab_pin.sym} 2137 40845 0 1 {name=l2177_4 lab=VDD}
N 2117 40865 2137 40865 {lab=VDD}
C {./lab_pin.sym} 2137 40865 0 1 {name=l2177_5 lab=VDD}
N 2117 40885 2137 40885 {lab=VSS}
C {./lab_pin.sym} 2137 40885 0 1 {name=l2177_6 lab=VSS}
N 2117 40905 2137 40905 {lab=VSS}
C {./lab_pin.sym} 2137 40905 0 1 {name=l2177_7 lab=VSS}
C {./dffrnq_1.sym} 2430 40875 0 0 {name=Xn_2119}
N 2338 40845 2318 40845 {lab=n_0103}
C {./lab_pin.sym} 2318 40845 0 0 {name=l2178_0 lab=n_0103}
N 2338 40865 2318 40865 {lab=net21}
C {./lab_pin.sym} 2318 40865 0 0 {name=l2178_1 lab=net21}
N 2338 40885 2318 40885 {lab=clknet_3_5__leaf_clk}
C {./lab_pin.sym} 2318 40885 0 0 {name=l2178_2 lab=clknet_3_5__leaf_clk}
N 2338 40905 2318 40905 {lab=u_cas_int_out_int2_b24}
C {./lab_pin.sym} 2318 40905 0 0 {name=l2178_3 lab=u_cas_int_out_int2_b24}
N 2522 40845 2542 40845 {lab=VDD}
C {./lab_pin.sym} 2542 40845 0 1 {name=l2178_4 lab=VDD}
N 2522 40865 2542 40865 {lab=VDD}
C {./lab_pin.sym} 2542 40865 0 1 {name=l2178_5 lab=VDD}
N 2522 40885 2542 40885 {lab=VSS}
C {./lab_pin.sym} 2542 40885 0 1 {name=l2178_6 lab=VSS}
N 2522 40905 2542 40905 {lab=VSS}
C {./lab_pin.sym} 2542 40905 0 1 {name=l2178_7 lab=VSS}
C {./dffrnq_1.sym} 2835 40875 0 0 {name=Xn_2120}
N 2743 40845 2723 40845 {lab=n_0062}
C {./lab_pin.sym} 2723 40845 0 0 {name=l2179_0 lab=n_0062}
N 2743 40865 2723 40865 {lab=net17}
C {./lab_pin.sym} 2723 40865 0 0 {name=l2179_1 lab=net17}
N 2743 40885 2723 40885 {lab=clknet_3_0__leaf_clk}
C {./lab_pin.sym} 2723 40885 0 0 {name=l2179_2 lab=clknet_3_0__leaf_clk}
N 2743 40905 2723 40905 {lab=u_cas_int_out_int1_b0}
C {./lab_pin.sym} 2723 40905 0 0 {name=l2179_3 lab=u_cas_int_out_int1_b0}
N 2927 40845 2947 40845 {lab=VDD}
C {./lab_pin.sym} 2947 40845 0 1 {name=l2179_4 lab=VDD}
N 2927 40865 2947 40865 {lab=VDD}
C {./lab_pin.sym} 2947 40865 0 1 {name=l2179_5 lab=VDD}
N 2927 40885 2947 40885 {lab=VSS}
C {./lab_pin.sym} 2947 40885 0 1 {name=l2179_6 lab=VSS}
N 2927 40905 2947 40905 {lab=VSS}
C {./lab_pin.sym} 2947 40905 0 1 {name=l2179_7 lab=VSS}
C {./dffrnq_1.sym} 3240 40875 0 0 {name=Xn_2121}
N 3148 40845 3128 40845 {lab=n_0073}
C {./lab_pin.sym} 3128 40845 0 0 {name=l2180_0 lab=n_0073}
N 3148 40865 3128 40865 {lab=net17}
C {./lab_pin.sym} 3128 40865 0 0 {name=l2180_1 lab=net17}
N 3148 40885 3128 40885 {lab=clknet_3_0__leaf_clk}
C {./lab_pin.sym} 3128 40885 0 0 {name=l2180_2 lab=clknet_3_0__leaf_clk}
N 3148 40905 3128 40905 {lab=u_cas_int_out_int1_b1}
C {./lab_pin.sym} 3128 40905 0 0 {name=l2180_3 lab=u_cas_int_out_int1_b1}
N 3332 40845 3352 40845 {lab=VDD}
C {./lab_pin.sym} 3352 40845 0 1 {name=l2180_4 lab=VDD}
N 3332 40865 3352 40865 {lab=VDD}
C {./lab_pin.sym} 3352 40865 0 1 {name=l2180_5 lab=VDD}
N 3332 40885 3352 40885 {lab=VSS}
C {./lab_pin.sym} 3352 40885 0 1 {name=l2180_6 lab=VSS}
N 3332 40905 3352 40905 {lab=VSS}
C {./lab_pin.sym} 3352 40905 0 1 {name=l2180_7 lab=VSS}
C {./dffrnq_1.sym} 3645 40875 0 0 {name=Xn_2122}
N 3553 40845 3533 40845 {lab=n_0079}
C {./lab_pin.sym} 3533 40845 0 0 {name=l2181_0 lab=n_0079}
N 3553 40865 3533 40865 {lab=net17}
C {./lab_pin.sym} 3533 40865 0 0 {name=l2181_1 lab=net17}
N 3553 40885 3533 40885 {lab=clknet_3_0__leaf_clk}
C {./lab_pin.sym} 3533 40885 0 0 {name=l2181_2 lab=clknet_3_0__leaf_clk}
N 3553 40905 3533 40905 {lab=u_cas_int_out_int1_b2}
C {./lab_pin.sym} 3533 40905 0 0 {name=l2181_3 lab=u_cas_int_out_int1_b2}
N 3737 40845 3757 40845 {lab=VDD}
C {./lab_pin.sym} 3757 40845 0 1 {name=l2181_4 lab=VDD}
N 3737 40865 3757 40865 {lab=VDD}
C {./lab_pin.sym} 3757 40865 0 1 {name=l2181_5 lab=VDD}
N 3737 40885 3757 40885 {lab=VSS}
C {./lab_pin.sym} 3757 40885 0 1 {name=l2181_6 lab=VSS}
N 3737 40905 3757 40905 {lab=VSS}
C {./lab_pin.sym} 3757 40905 0 1 {name=l2181_7 lab=VSS}
C {./dffrnq_1.sym} 4050 40875 0 0 {name=Xn_2123}
N 3958 40845 3938 40845 {lab=n_0080}
C {./lab_pin.sym} 3938 40845 0 0 {name=l2182_0 lab=n_0080}
N 3958 40865 3938 40865 {lab=net17}
C {./lab_pin.sym} 3938 40865 0 0 {name=l2182_1 lab=net17}
N 3958 40885 3938 40885 {lab=clknet_3_0__leaf_clk}
C {./lab_pin.sym} 3938 40885 0 0 {name=l2182_2 lab=clknet_3_0__leaf_clk}
N 3958 40905 3938 40905 {lab=u_cas_int_out_int1_b3}
C {./lab_pin.sym} 3938 40905 0 0 {name=l2182_3 lab=u_cas_int_out_int1_b3}
N 4142 40845 4162 40845 {lab=VDD}
C {./lab_pin.sym} 4162 40845 0 1 {name=l2182_4 lab=VDD}
N 4142 40865 4162 40865 {lab=VDD}
C {./lab_pin.sym} 4162 40865 0 1 {name=l2182_5 lab=VDD}
N 4142 40885 4162 40885 {lab=VSS}
C {./lab_pin.sym} 4162 40885 0 1 {name=l2182_6 lab=VSS}
N 4142 40905 4162 40905 {lab=VSS}
C {./lab_pin.sym} 4162 40905 0 1 {name=l2182_7 lab=VSS}
C {./dffrnq_1.sym} 4455 40875 0 0 {name=Xn_2124}
N 4363 40845 4343 40845 {lab=n_0081}
C {./lab_pin.sym} 4343 40845 0 0 {name=l2183_0 lab=n_0081}
N 4363 40865 4343 40865 {lab=net17}
C {./lab_pin.sym} 4343 40865 0 0 {name=l2183_1 lab=net17}
N 4363 40885 4343 40885 {lab=clknet_3_0__leaf_clk}
C {./lab_pin.sym} 4343 40885 0 0 {name=l2183_2 lab=clknet_3_0__leaf_clk}
N 4363 40905 4343 40905 {lab=u_cas_int_out_int1_b4}
C {./lab_pin.sym} 4343 40905 0 0 {name=l2183_3 lab=u_cas_int_out_int1_b4}
N 4547 40845 4567 40845 {lab=VDD}
C {./lab_pin.sym} 4567 40845 0 1 {name=l2183_4 lab=VDD}
N 4547 40865 4567 40865 {lab=VDD}
C {./lab_pin.sym} 4567 40865 0 1 {name=l2183_5 lab=VDD}
N 4547 40885 4567 40885 {lab=VSS}
C {./lab_pin.sym} 4567 40885 0 1 {name=l2183_6 lab=VSS}
N 4547 40905 4567 40905 {lab=VSS}
C {./lab_pin.sym} 4567 40905 0 1 {name=l2183_7 lab=VSS}
C {./dffrnq_1.sym} 0 41100 0 0 {name=Xn_2125}
N -92 41070 -112 41070 {lab=n_0082}
C {./lab_pin.sym} -112 41070 0 0 {name=l2184_0 lab=n_0082}
N -92 41090 -112 41090 {lab=net17}
C {./lab_pin.sym} -112 41090 0 0 {name=l2184_1 lab=net17}
N -92 41110 -112 41110 {lab=clknet_3_0__leaf_clk}
C {./lab_pin.sym} -112 41110 0 0 {name=l2184_2 lab=clknet_3_0__leaf_clk}
N -92 41130 -112 41130 {lab=u_cas_int_out_int1_b5}
C {./lab_pin.sym} -112 41130 0 0 {name=l2184_3 lab=u_cas_int_out_int1_b5}
N 92 41070 112 41070 {lab=VDD}
C {./lab_pin.sym} 112 41070 0 1 {name=l2184_4 lab=VDD}
N 92 41090 112 41090 {lab=VDD}
C {./lab_pin.sym} 112 41090 0 1 {name=l2184_5 lab=VDD}
N 92 41110 112 41110 {lab=VSS}
C {./lab_pin.sym} 112 41110 0 1 {name=l2184_6 lab=VSS}
N 92 41130 112 41130 {lab=VSS}
C {./lab_pin.sym} 112 41130 0 1 {name=l2184_7 lab=VSS}
C {./dffrnq_1.sym} 405 41100 0 0 {name=Xn_2126}
N 313 41070 293 41070 {lab=n_0083}
C {./lab_pin.sym} 293 41070 0 0 {name=l2185_0 lab=n_0083}
N 313 41090 293 41090 {lab=net17}
C {./lab_pin.sym} 293 41090 0 0 {name=l2185_1 lab=net17}
N 313 41110 293 41110 {lab=clknet_3_0__leaf_clk}
C {./lab_pin.sym} 293 41110 0 0 {name=l2185_2 lab=clknet_3_0__leaf_clk}
N 313 41130 293 41130 {lab=u_cas_int_out_int1_b6}
C {./lab_pin.sym} 293 41130 0 0 {name=l2185_3 lab=u_cas_int_out_int1_b6}
N 497 41070 517 41070 {lab=VDD}
C {./lab_pin.sym} 517 41070 0 1 {name=l2185_4 lab=VDD}
N 497 41090 517 41090 {lab=VDD}
C {./lab_pin.sym} 517 41090 0 1 {name=l2185_5 lab=VDD}
N 497 41110 517 41110 {lab=VSS}
C {./lab_pin.sym} 517 41110 0 1 {name=l2185_6 lab=VSS}
N 497 41130 517 41130 {lab=VSS}
C {./lab_pin.sym} 517 41130 0 1 {name=l2185_7 lab=VSS}
C {./dffrnq_1.sym} 810 41100 0 0 {name=Xn_2127}
N 718 41070 698 41070 {lab=n_0084}
C {./lab_pin.sym} 698 41070 0 0 {name=l2186_0 lab=n_0084}
N 718 41090 698 41090 {lab=net17}
C {./lab_pin.sym} 698 41090 0 0 {name=l2186_1 lab=net17}
N 718 41110 698 41110 {lab=clknet_3_0__leaf_clk}
C {./lab_pin.sym} 698 41110 0 0 {name=l2186_2 lab=clknet_3_0__leaf_clk}
N 718 41130 698 41130 {lab=u_cas_int_out_int1_b7}
C {./lab_pin.sym} 698 41130 0 0 {name=l2186_3 lab=u_cas_int_out_int1_b7}
N 902 41070 922 41070 {lab=VDD}
C {./lab_pin.sym} 922 41070 0 1 {name=l2186_4 lab=VDD}
N 902 41090 922 41090 {lab=VDD}
C {./lab_pin.sym} 922 41090 0 1 {name=l2186_5 lab=VDD}
N 902 41110 922 41110 {lab=VSS}
C {./lab_pin.sym} 922 41110 0 1 {name=l2186_6 lab=VSS}
N 902 41130 922 41130 {lab=VSS}
C {./lab_pin.sym} 922 41130 0 1 {name=l2186_7 lab=VSS}
C {./dffrnq_1.sym} 1215 41100 0 0 {name=Xn_2128}
N 1123 41070 1103 41070 {lab=n_0085}
C {./lab_pin.sym} 1103 41070 0 0 {name=l2187_0 lab=n_0085}
N 1123 41090 1103 41090 {lab=net17}
C {./lab_pin.sym} 1103 41090 0 0 {name=l2187_1 lab=net17}
N 1123 41110 1103 41110 {lab=clknet_3_1__leaf_clk}
C {./lab_pin.sym} 1103 41110 0 0 {name=l2187_2 lab=clknet_3_1__leaf_clk}
N 1123 41130 1103 41130 {lab=u_cas_int_out_int1_b8}
C {./lab_pin.sym} 1103 41130 0 0 {name=l2187_3 lab=u_cas_int_out_int1_b8}
N 1307 41070 1327 41070 {lab=VDD}
C {./lab_pin.sym} 1327 41070 0 1 {name=l2187_4 lab=VDD}
N 1307 41090 1327 41090 {lab=VDD}
C {./lab_pin.sym} 1327 41090 0 1 {name=l2187_5 lab=VDD}
N 1307 41110 1327 41110 {lab=VSS}
C {./lab_pin.sym} 1327 41110 0 1 {name=l2187_6 lab=VSS}
N 1307 41130 1327 41130 {lab=VSS}
C {./lab_pin.sym} 1327 41130 0 1 {name=l2187_7 lab=VSS}
C {./dffrnq_1.sym} 1620 41100 0 0 {name=Xn_2129}
N 1528 41070 1508 41070 {lab=n_0086}
C {./lab_pin.sym} 1508 41070 0 0 {name=l2188_0 lab=n_0086}
N 1528 41090 1508 41090 {lab=net17}
C {./lab_pin.sym} 1508 41090 0 0 {name=l2188_1 lab=net17}
N 1528 41110 1508 41110 {lab=clknet_3_1__leaf_clk}
C {./lab_pin.sym} 1508 41110 0 0 {name=l2188_2 lab=clknet_3_1__leaf_clk}
N 1528 41130 1508 41130 {lab=u_cas_int_out_int1_b9}
C {./lab_pin.sym} 1508 41130 0 0 {name=l2188_3 lab=u_cas_int_out_int1_b9}
N 1712 41070 1732 41070 {lab=VDD}
C {./lab_pin.sym} 1732 41070 0 1 {name=l2188_4 lab=VDD}
N 1712 41090 1732 41090 {lab=VDD}
C {./lab_pin.sym} 1732 41090 0 1 {name=l2188_5 lab=VDD}
N 1712 41110 1732 41110 {lab=VSS}
C {./lab_pin.sym} 1732 41110 0 1 {name=l2188_6 lab=VSS}
N 1712 41130 1732 41130 {lab=VSS}
C {./lab_pin.sym} 1732 41130 0 1 {name=l2188_7 lab=VSS}
C {./dffrnq_1.sym} 2025 41100 0 0 {name=Xn_2130}
N 1933 41070 1913 41070 {lab=n_0063}
C {./lab_pin.sym} 1913 41070 0 0 {name=l2189_0 lab=n_0063}
N 1933 41090 1913 41090 {lab=net17}
C {./lab_pin.sym} 1913 41090 0 0 {name=l2189_1 lab=net17}
N 1933 41110 1913 41110 {lab=clknet_3_1__leaf_clk}
C {./lab_pin.sym} 1913 41110 0 0 {name=l2189_2 lab=clknet_3_1__leaf_clk}
N 1933 41130 1913 41130 {lab=u_cas_int_out_int1_b10}
C {./lab_pin.sym} 1913 41130 0 0 {name=l2189_3 lab=u_cas_int_out_int1_b10}
N 2117 41070 2137 41070 {lab=VDD}
C {./lab_pin.sym} 2137 41070 0 1 {name=l2189_4 lab=VDD}
N 2117 41090 2137 41090 {lab=VDD}
C {./lab_pin.sym} 2137 41090 0 1 {name=l2189_5 lab=VDD}
N 2117 41110 2137 41110 {lab=VSS}
C {./lab_pin.sym} 2137 41110 0 1 {name=l2189_6 lab=VSS}
N 2117 41130 2137 41130 {lab=VSS}
C {./lab_pin.sym} 2137 41130 0 1 {name=l2189_7 lab=VSS}
C {./dffrnq_1.sym} 2430 41100 0 0 {name=Xn_2131}
N 2338 41070 2318 41070 {lab=n_0064}
C {./lab_pin.sym} 2318 41070 0 0 {name=l2190_0 lab=n_0064}
N 2338 41090 2318 41090 {lab=net17}
C {./lab_pin.sym} 2318 41090 0 0 {name=l2190_1 lab=net17}
N 2338 41110 2318 41110 {lab=clknet_3_1__leaf_clk}
C {./lab_pin.sym} 2318 41110 0 0 {name=l2190_2 lab=clknet_3_1__leaf_clk}
N 2338 41130 2318 41130 {lab=u_cas_int_out_int1_b11}
C {./lab_pin.sym} 2318 41130 0 0 {name=l2190_3 lab=u_cas_int_out_int1_b11}
N 2522 41070 2542 41070 {lab=VDD}
C {./lab_pin.sym} 2542 41070 0 1 {name=l2190_4 lab=VDD}
N 2522 41090 2542 41090 {lab=VDD}
C {./lab_pin.sym} 2542 41090 0 1 {name=l2190_5 lab=VDD}
N 2522 41110 2542 41110 {lab=VSS}
C {./lab_pin.sym} 2542 41110 0 1 {name=l2190_6 lab=VSS}
N 2522 41130 2542 41130 {lab=VSS}
C {./lab_pin.sym} 2542 41130 0 1 {name=l2190_7 lab=VSS}
C {./dffrnq_1.sym} 2835 41100 0 0 {name=Xn_2132}
N 2743 41070 2723 41070 {lab=n_0065}
C {./lab_pin.sym} 2723 41070 0 0 {name=l2191_0 lab=n_0065}
N 2743 41090 2723 41090 {lab=net17}
C {./lab_pin.sym} 2723 41090 0 0 {name=l2191_1 lab=net17}
N 2743 41110 2723 41110 {lab=clknet_3_4__leaf_clk}
C {./lab_pin.sym} 2723 41110 0 0 {name=l2191_2 lab=clknet_3_4__leaf_clk}
N 2743 41130 2723 41130 {lab=u_cas_int_out_int1_b12}
C {./lab_pin.sym} 2723 41130 0 0 {name=l2191_3 lab=u_cas_int_out_int1_b12}
N 2927 41070 2947 41070 {lab=VDD}
C {./lab_pin.sym} 2947 41070 0 1 {name=l2191_4 lab=VDD}
N 2927 41090 2947 41090 {lab=VDD}
C {./lab_pin.sym} 2947 41090 0 1 {name=l2191_5 lab=VDD}
N 2927 41110 2947 41110 {lab=VSS}
C {./lab_pin.sym} 2947 41110 0 1 {name=l2191_6 lab=VSS}
N 2927 41130 2947 41130 {lab=VSS}
C {./lab_pin.sym} 2947 41130 0 1 {name=l2191_7 lab=VSS}
C {./dffrnq_1.sym} 3240 41100 0 0 {name=Xn_2133}
N 3148 41070 3128 41070 {lab=n_0066}
C {./lab_pin.sym} 3128 41070 0 0 {name=l2192_0 lab=n_0066}
N 3148 41090 3128 41090 {lab=net17}
C {./lab_pin.sym} 3128 41090 0 0 {name=l2192_1 lab=net17}
N 3148 41110 3128 41110 {lab=clknet_3_4__leaf_clk}
C {./lab_pin.sym} 3128 41110 0 0 {name=l2192_2 lab=clknet_3_4__leaf_clk}
N 3148 41130 3128 41130 {lab=u_cas_int_out_int1_b13}
C {./lab_pin.sym} 3128 41130 0 0 {name=l2192_3 lab=u_cas_int_out_int1_b13}
N 3332 41070 3352 41070 {lab=VDD}
C {./lab_pin.sym} 3352 41070 0 1 {name=l2192_4 lab=VDD}
N 3332 41090 3352 41090 {lab=VDD}
C {./lab_pin.sym} 3352 41090 0 1 {name=l2192_5 lab=VDD}
N 3332 41110 3352 41110 {lab=VSS}
C {./lab_pin.sym} 3352 41110 0 1 {name=l2192_6 lab=VSS}
N 3332 41130 3352 41130 {lab=VSS}
C {./lab_pin.sym} 3352 41130 0 1 {name=l2192_7 lab=VSS}
C {./dffrnq_1.sym} 3645 41100 0 0 {name=Xn_2134}
N 3553 41070 3533 41070 {lab=n_0067}
C {./lab_pin.sym} 3533 41070 0 0 {name=l2193_0 lab=n_0067}
N 3553 41090 3533 41090 {lab=net17}
C {./lab_pin.sym} 3533 41090 0 0 {name=l2193_1 lab=net17}
N 3553 41110 3533 41110 {lab=clknet_3_4__leaf_clk}
C {./lab_pin.sym} 3533 41110 0 0 {name=l2193_2 lab=clknet_3_4__leaf_clk}
N 3553 41130 3533 41130 {lab=u_cas_int_out_int1_b14}
C {./lab_pin.sym} 3533 41130 0 0 {name=l2193_3 lab=u_cas_int_out_int1_b14}
N 3737 41070 3757 41070 {lab=VDD}
C {./lab_pin.sym} 3757 41070 0 1 {name=l2193_4 lab=VDD}
N 3737 41090 3757 41090 {lab=VDD}
C {./lab_pin.sym} 3757 41090 0 1 {name=l2193_5 lab=VDD}
N 3737 41110 3757 41110 {lab=VSS}
C {./lab_pin.sym} 3757 41110 0 1 {name=l2193_6 lab=VSS}
N 3737 41130 3757 41130 {lab=VSS}
C {./lab_pin.sym} 3757 41130 0 1 {name=l2193_7 lab=VSS}
C {./dffrnq_1.sym} 4050 41100 0 0 {name=Xn_2135}
N 3958 41070 3938 41070 {lab=n_0068}
C {./lab_pin.sym} 3938 41070 0 0 {name=l2194_0 lab=n_0068}
N 3958 41090 3938 41090 {lab=net17}
C {./lab_pin.sym} 3938 41090 0 0 {name=l2194_1 lab=net17}
N 3958 41110 3938 41110 {lab=clknet_3_1__leaf_clk}
C {./lab_pin.sym} 3938 41110 0 0 {name=l2194_2 lab=clknet_3_1__leaf_clk}
N 3958 41130 3938 41130 {lab=u_cas_int_out_int1_b15}
C {./lab_pin.sym} 3938 41130 0 0 {name=l2194_3 lab=u_cas_int_out_int1_b15}
N 4142 41070 4162 41070 {lab=VDD}
C {./lab_pin.sym} 4162 41070 0 1 {name=l2194_4 lab=VDD}
N 4142 41090 4162 41090 {lab=VDD}
C {./lab_pin.sym} 4162 41090 0 1 {name=l2194_5 lab=VDD}
N 4142 41110 4162 41110 {lab=VSS}
C {./lab_pin.sym} 4162 41110 0 1 {name=l2194_6 lab=VSS}
N 4142 41130 4162 41130 {lab=VSS}
C {./lab_pin.sym} 4162 41130 0 1 {name=l2194_7 lab=VSS}
C {./dffrnq_1.sym} 4455 41100 0 0 {name=Xn_2136}
N 4363 41070 4343 41070 {lab=n_0069}
C {./lab_pin.sym} 4343 41070 0 0 {name=l2195_0 lab=n_0069}
N 4363 41090 4343 41090 {lab=net17}
C {./lab_pin.sym} 4343 41090 0 0 {name=l2195_1 lab=net17}
N 4363 41110 4343 41110 {lab=clknet_3_4__leaf_clk}
C {./lab_pin.sym} 4343 41110 0 0 {name=l2195_2 lab=clknet_3_4__leaf_clk}
N 4363 41130 4343 41130 {lab=u_cas_int_out_int1_b16}
C {./lab_pin.sym} 4343 41130 0 0 {name=l2195_3 lab=u_cas_int_out_int1_b16}
N 4547 41070 4567 41070 {lab=VDD}
C {./lab_pin.sym} 4567 41070 0 1 {name=l2195_4 lab=VDD}
N 4547 41090 4567 41090 {lab=VDD}
C {./lab_pin.sym} 4567 41090 0 1 {name=l2195_5 lab=VDD}
N 4547 41110 4567 41110 {lab=VSS}
C {./lab_pin.sym} 4567 41110 0 1 {name=l2195_6 lab=VSS}
N 4547 41130 4567 41130 {lab=VSS}
C {./lab_pin.sym} 4567 41130 0 1 {name=l2195_7 lab=VSS}
C {./dffrnq_1.sym} 0 41325 0 0 {name=Xn_2137}
N -92 41295 -112 41295 {lab=n_0070}
C {./lab_pin.sym} -112 41295 0 0 {name=l2196_0 lab=n_0070}
N -92 41315 -112 41315 {lab=net17}
C {./lab_pin.sym} -112 41315 0 0 {name=l2196_1 lab=net17}
N -92 41335 -112 41335 {lab=clknet_3_4__leaf_clk}
C {./lab_pin.sym} -112 41335 0 0 {name=l2196_2 lab=clknet_3_4__leaf_clk}
N -92 41355 -112 41355 {lab=u_cas_int_out_int1_b17}
C {./lab_pin.sym} -112 41355 0 0 {name=l2196_3 lab=u_cas_int_out_int1_b17}
N 92 41295 112 41295 {lab=VDD}
C {./lab_pin.sym} 112 41295 0 1 {name=l2196_4 lab=VDD}
N 92 41315 112 41315 {lab=VDD}
C {./lab_pin.sym} 112 41315 0 1 {name=l2196_5 lab=VDD}
N 92 41335 112 41335 {lab=VSS}
C {./lab_pin.sym} 112 41335 0 1 {name=l2196_6 lab=VSS}
N 92 41355 112 41355 {lab=VSS}
C {./lab_pin.sym} 112 41355 0 1 {name=l2196_7 lab=VSS}
C {./dffrnq_1.sym} 405 41325 0 0 {name=Xn_2138}
N 313 41295 293 41295 {lab=n_0071}
C {./lab_pin.sym} 293 41295 0 0 {name=l2197_0 lab=n_0071}
N 313 41315 293 41315 {lab=net17}
C {./lab_pin.sym} 293 41315 0 0 {name=l2197_1 lab=net17}
N 313 41335 293 41335 {lab=clknet_3_4__leaf_clk}
C {./lab_pin.sym} 293 41335 0 0 {name=l2197_2 lab=clknet_3_4__leaf_clk}
N 313 41355 293 41355 {lab=u_cas_int_out_int1_b18}
C {./lab_pin.sym} 293 41355 0 0 {name=l2197_3 lab=u_cas_int_out_int1_b18}
N 497 41295 517 41295 {lab=VDD}
C {./lab_pin.sym} 517 41295 0 1 {name=l2197_4 lab=VDD}
N 497 41315 517 41315 {lab=VDD}
C {./lab_pin.sym} 517 41315 0 1 {name=l2197_5 lab=VDD}
N 497 41335 517 41335 {lab=VSS}
C {./lab_pin.sym} 517 41335 0 1 {name=l2197_6 lab=VSS}
N 497 41355 517 41355 {lab=VSS}
C {./lab_pin.sym} 517 41355 0 1 {name=l2197_7 lab=VSS}
C {./dffrnq_1.sym} 810 41325 0 0 {name=Xn_2139}
N 718 41295 698 41295 {lab=n_0072}
C {./lab_pin.sym} 698 41295 0 0 {name=l2198_0 lab=n_0072}
N 718 41315 698 41315 {lab=net17}
C {./lab_pin.sym} 698 41315 0 0 {name=l2198_1 lab=net17}
N 718 41335 698 41335 {lab=clknet_3_5__leaf_clk}
C {./lab_pin.sym} 698 41335 0 0 {name=l2198_2 lab=clknet_3_5__leaf_clk}
N 718 41355 698 41355 {lab=u_cas_int_out_int1_b19}
C {./lab_pin.sym} 698 41355 0 0 {name=l2198_3 lab=u_cas_int_out_int1_b19}
N 902 41295 922 41295 {lab=VDD}
C {./lab_pin.sym} 922 41295 0 1 {name=l2198_4 lab=VDD}
N 902 41315 922 41315 {lab=VDD}
C {./lab_pin.sym} 922 41315 0 1 {name=l2198_5 lab=VDD}
N 902 41335 922 41335 {lab=VSS}
C {./lab_pin.sym} 922 41335 0 1 {name=l2198_6 lab=VSS}
N 902 41355 922 41355 {lab=VSS}
C {./lab_pin.sym} 922 41355 0 1 {name=l2198_7 lab=VSS}
C {./dffrnq_1.sym} 1215 41325 0 0 {name=Xn_2140}
N 1123 41295 1103 41295 {lab=n_0074}
C {./lab_pin.sym} 1103 41295 0 0 {name=l2199_0 lab=n_0074}
N 1123 41315 1103 41315 {lab=net17}
C {./lab_pin.sym} 1103 41315 0 0 {name=l2199_1 lab=net17}
N 1123 41335 1103 41335 {lab=clknet_3_5__leaf_clk}
C {./lab_pin.sym} 1103 41335 0 0 {name=l2199_2 lab=clknet_3_5__leaf_clk}
N 1123 41355 1103 41355 {lab=u_cas_int_out_int1_b20}
C {./lab_pin.sym} 1103 41355 0 0 {name=l2199_3 lab=u_cas_int_out_int1_b20}
N 1307 41295 1327 41295 {lab=VDD}
C {./lab_pin.sym} 1327 41295 0 1 {name=l2199_4 lab=VDD}
N 1307 41315 1327 41315 {lab=VDD}
C {./lab_pin.sym} 1327 41315 0 1 {name=l2199_5 lab=VDD}
N 1307 41335 1327 41335 {lab=VSS}
C {./lab_pin.sym} 1327 41335 0 1 {name=l2199_6 lab=VSS}
N 1307 41355 1327 41355 {lab=VSS}
C {./lab_pin.sym} 1327 41355 0 1 {name=l2199_7 lab=VSS}
C {./dffrnq_1.sym} 1620 41325 0 0 {name=Xn_2141}
N 1528 41295 1508 41295 {lab=n_0075}
C {./lab_pin.sym} 1508 41295 0 0 {name=l2200_0 lab=n_0075}
N 1528 41315 1508 41315 {lab=net17}
C {./lab_pin.sym} 1508 41315 0 0 {name=l2200_1 lab=net17}
N 1528 41335 1508 41335 {lab=clknet_3_5__leaf_clk}
C {./lab_pin.sym} 1508 41335 0 0 {name=l2200_2 lab=clknet_3_5__leaf_clk}
N 1528 41355 1508 41355 {lab=u_cas_int_out_int1_b21}
C {./lab_pin.sym} 1508 41355 0 0 {name=l2200_3 lab=u_cas_int_out_int1_b21}
N 1712 41295 1732 41295 {lab=VDD}
C {./lab_pin.sym} 1732 41295 0 1 {name=l2200_4 lab=VDD}
N 1712 41315 1732 41315 {lab=VDD}
C {./lab_pin.sym} 1732 41315 0 1 {name=l2200_5 lab=VDD}
N 1712 41335 1732 41335 {lab=VSS}
C {./lab_pin.sym} 1732 41335 0 1 {name=l2200_6 lab=VSS}
N 1712 41355 1732 41355 {lab=VSS}
C {./lab_pin.sym} 1732 41355 0 1 {name=l2200_7 lab=VSS}
C {./dffrnq_1.sym} 2025 41325 0 0 {name=Xn_2142}
N 1933 41295 1913 41295 {lab=n_0076}
C {./lab_pin.sym} 1913 41295 0 0 {name=l2201_0 lab=n_0076}
N 1933 41315 1913 41315 {lab=net17}
C {./lab_pin.sym} 1913 41315 0 0 {name=l2201_1 lab=net17}
N 1933 41335 1913 41335 {lab=clknet_3_5__leaf_clk}
C {./lab_pin.sym} 1913 41335 0 0 {name=l2201_2 lab=clknet_3_5__leaf_clk}
N 1933 41355 1913 41355 {lab=u_cas_int_out_int1_b22}
C {./lab_pin.sym} 1913 41355 0 0 {name=l2201_3 lab=u_cas_int_out_int1_b22}
N 2117 41295 2137 41295 {lab=VDD}
C {./lab_pin.sym} 2137 41295 0 1 {name=l2201_4 lab=VDD}
N 2117 41315 2137 41315 {lab=VDD}
C {./lab_pin.sym} 2137 41315 0 1 {name=l2201_5 lab=VDD}
N 2117 41335 2137 41335 {lab=VSS}
C {./lab_pin.sym} 2137 41335 0 1 {name=l2201_6 lab=VSS}
N 2117 41355 2137 41355 {lab=VSS}
C {./lab_pin.sym} 2137 41355 0 1 {name=l2201_7 lab=VSS}
C {./dffrnq_1.sym} 2430 41325 0 0 {name=Xn_2143}
N 2338 41295 2318 41295 {lab=n_0077}
C {./lab_pin.sym} 2318 41295 0 0 {name=l2202_0 lab=n_0077}
N 2338 41315 2318 41315 {lab=net17}
C {./lab_pin.sym} 2318 41315 0 0 {name=l2202_1 lab=net17}
N 2338 41335 2318 41335 {lab=clknet_3_5__leaf_clk}
C {./lab_pin.sym} 2318 41335 0 0 {name=l2202_2 lab=clknet_3_5__leaf_clk}
N 2338 41355 2318 41355 {lab=u_cas_int_out_int1_b23}
C {./lab_pin.sym} 2318 41355 0 0 {name=l2202_3 lab=u_cas_int_out_int1_b23}
N 2522 41295 2542 41295 {lab=VDD}
C {./lab_pin.sym} 2542 41295 0 1 {name=l2202_4 lab=VDD}
N 2522 41315 2542 41315 {lab=VDD}
C {./lab_pin.sym} 2542 41315 0 1 {name=l2202_5 lab=VDD}
N 2522 41335 2542 41335 {lab=VSS}
C {./lab_pin.sym} 2542 41335 0 1 {name=l2202_6 lab=VSS}
N 2522 41355 2542 41355 {lab=VSS}
C {./lab_pin.sym} 2542 41355 0 1 {name=l2202_7 lab=VSS}
C {./dffrnq_1.sym} 2835 41325 0 0 {name=Xn_2144}
N 2743 41295 2723 41295 {lab=n_0078}
C {./lab_pin.sym} 2723 41295 0 0 {name=l2203_0 lab=n_0078}
N 2743 41315 2723 41315 {lab=net17}
C {./lab_pin.sym} 2723 41315 0 0 {name=l2203_1 lab=net17}
N 2743 41335 2723 41335 {lab=clknet_3_5__leaf_clk}
C {./lab_pin.sym} 2723 41335 0 0 {name=l2203_2 lab=clknet_3_5__leaf_clk}
N 2743 41355 2723 41355 {lab=u_cas_int_out_int1_b24}
C {./lab_pin.sym} 2723 41355 0 0 {name=l2203_3 lab=u_cas_int_out_int1_b24}
N 2927 41295 2947 41295 {lab=VDD}
C {./lab_pin.sym} 2947 41295 0 1 {name=l2203_4 lab=VDD}
N 2927 41315 2947 41315 {lab=VDD}
C {./lab_pin.sym} 2947 41315 0 1 {name=l2203_5 lab=VDD}
N 2927 41335 2947 41335 {lab=VSS}
C {./lab_pin.sym} 2947 41335 0 1 {name=l2203_6 lab=VSS}
N 2927 41355 2947 41355 {lab=VSS}
C {./lab_pin.sym} 2947 41355 0 1 {name=l2203_7 lab=VSS}
C {./dffrnq_1.sym} 3240 41325 0 0 {name=Xn_2145}
N 3148 41295 3128 41295 {lab=n_0137}
C {./lab_pin.sym} 3128 41295 0 0 {name=l2204_0 lab=n_0137}
N 3148 41315 3128 41315 {lab=net17}
C {./lab_pin.sym} 3128 41315 0 0 {name=l2204_1 lab=net17}
N 3148 41335 3128 41335 {lab=clknet_3_0__leaf_clk}
C {./lab_pin.sym} 3128 41335 0 0 {name=l2204_2 lab=clknet_3_0__leaf_clk}
N 3148 41355 3128 41355 {lab=u_clock_div_counter_b0}
C {./lab_pin.sym} 3128 41355 0 0 {name=l2204_3 lab=u_clock_div_counter_b0}
N 3332 41295 3352 41295 {lab=VDD}
C {./lab_pin.sym} 3352 41295 0 1 {name=l2204_4 lab=VDD}
N 3332 41315 3352 41315 {lab=VDD}
C {./lab_pin.sym} 3352 41315 0 1 {name=l2204_5 lab=VDD}
N 3332 41335 3352 41335 {lab=VSS}
C {./lab_pin.sym} 3352 41335 0 1 {name=l2204_6 lab=VSS}
N 3332 41355 3352 41355 {lab=VSS}
C {./lab_pin.sym} 3352 41355 0 1 {name=l2204_7 lab=VSS}
C {./dffrnq_1.sym} 3645 41325 0 0 {name=Xn_2146}
N 3553 41295 3533 41295 {lab=n_0138}
C {./lab_pin.sym} 3533 41295 0 0 {name=l2205_0 lab=n_0138}
N 3553 41315 3533 41315 {lab=net17}
C {./lab_pin.sym} 3533 41315 0 0 {name=l2205_1 lab=net17}
N 3553 41335 3533 41335 {lab=clknet_3_0__leaf_clk}
C {./lab_pin.sym} 3533 41335 0 0 {name=l2205_2 lab=clknet_3_0__leaf_clk}
N 3553 41355 3533 41355 {lab=u_clock_div_counter_b1}
C {./lab_pin.sym} 3533 41355 0 0 {name=l2205_3 lab=u_clock_div_counter_b1}
N 3737 41295 3757 41295 {lab=VDD}
C {./lab_pin.sym} 3757 41295 0 1 {name=l2205_4 lab=VDD}
N 3737 41315 3757 41315 {lab=VDD}
C {./lab_pin.sym} 3757 41315 0 1 {name=l2205_5 lab=VDD}
N 3737 41335 3757 41335 {lab=VSS}
C {./lab_pin.sym} 3757 41335 0 1 {name=l2205_6 lab=VSS}
N 3737 41355 3757 41355 {lab=VSS}
C {./lab_pin.sym} 3757 41355 0 1 {name=l2205_7 lab=VSS}
C {./dffrnq_1.sym} 4050 41325 0 0 {name=Xn_2147}
N 3958 41295 3938 41295 {lab=n_0139}
C {./lab_pin.sym} 3938 41295 0 0 {name=l2206_0 lab=n_0139}
N 3958 41315 3938 41315 {lab=net17}
C {./lab_pin.sym} 3938 41315 0 0 {name=l2206_1 lab=net17}
N 3958 41335 3938 41335 {lab=clknet_3_0__leaf_clk}
C {./lab_pin.sym} 3938 41335 0 0 {name=l2206_2 lab=clknet_3_0__leaf_clk}
N 3958 41355 3938 41355 {lab=u_clock_div_counter_b2}
C {./lab_pin.sym} 3938 41355 0 0 {name=l2206_3 lab=u_clock_div_counter_b2}
N 4142 41295 4162 41295 {lab=VDD}
C {./lab_pin.sym} 4162 41295 0 1 {name=l2206_4 lab=VDD}
N 4142 41315 4162 41315 {lab=VDD}
C {./lab_pin.sym} 4162 41315 0 1 {name=l2206_5 lab=VDD}
N 4142 41335 4162 41335 {lab=VSS}
C {./lab_pin.sym} 4162 41335 0 1 {name=l2206_6 lab=VSS}
N 4142 41355 4162 41355 {lab=VSS}
C {./lab_pin.sym} 4162 41355 0 1 {name=l2206_7 lab=VSS}
C {./dffrnq_1.sym} 4455 41325 0 0 {name=Xn_2148}
N 4363 41295 4343 41295 {lab=n_0140}
C {./lab_pin.sym} 4343 41295 0 0 {name=l2207_0 lab=n_0140}
N 4363 41315 4343 41315 {lab=net17}
C {./lab_pin.sym} 4343 41315 0 0 {name=l2207_1 lab=net17}
N 4363 41335 4343 41335 {lab=clknet_3_0__leaf_clk}
C {./lab_pin.sym} 4343 41335 0 0 {name=l2207_2 lab=clknet_3_0__leaf_clk}
N 4363 41355 4343 41355 {lab=u_clock_div_counter_b3}
C {./lab_pin.sym} 4343 41355 0 0 {name=l2207_3 lab=u_clock_div_counter_b3}
N 4547 41295 4567 41295 {lab=VDD}
C {./lab_pin.sym} 4567 41295 0 1 {name=l2207_4 lab=VDD}
N 4547 41315 4567 41315 {lab=VDD}
C {./lab_pin.sym} 4567 41315 0 1 {name=l2207_5 lab=VDD}
N 4547 41335 4567 41335 {lab=VSS}
C {./lab_pin.sym} 4567 41335 0 1 {name=l2207_6 lab=VSS}
N 4547 41355 4567 41355 {lab=VSS}
C {./lab_pin.sym} 4567 41355 0 1 {name=l2207_7 lab=VSS}
C {./dffrnq_1.sym} 0 41550 0 0 {name=Xn_2149}
N -92 41520 -112 41520 {lab=n_0141}
C {./lab_pin.sym} -112 41520 0 0 {name=l2208_0 lab=n_0141}
N -92 41540 -112 41540 {lab=net17}
C {./lab_pin.sym} -112 41540 0 0 {name=l2208_1 lab=net17}
N -92 41560 -112 41560 {lab=clknet_3_0__leaf_clk}
C {./lab_pin.sym} -112 41560 0 0 {name=l2208_2 lab=clknet_3_0__leaf_clk}
N -92 41580 -112 41580 {lab=u_clock_div_counter_b4}
C {./lab_pin.sym} -112 41580 0 0 {name=l2208_3 lab=u_clock_div_counter_b4}
N 92 41520 112 41520 {lab=VDD}
C {./lab_pin.sym} 112 41520 0 1 {name=l2208_4 lab=VDD}
N 92 41540 112 41540 {lab=VDD}
C {./lab_pin.sym} 112 41540 0 1 {name=l2208_5 lab=VDD}
N 92 41560 112 41560 {lab=VSS}
C {./lab_pin.sym} 112 41560 0 1 {name=l2208_6 lab=VSS}
N 92 41580 112 41580 {lab=VSS}
C {./lab_pin.sym} 112 41580 0 1 {name=l2208_7 lab=VSS}
C {./dffrnq_1.sym} 405 41550 0 0 {name=Xn_2150}
N 313 41520 293 41520 {lab=n_0142}
C {./lab_pin.sym} 293 41520 0 0 {name=l2209_0 lab=n_0142}
N 313 41540 293 41540 {lab=net17}
C {./lab_pin.sym} 293 41540 0 0 {name=l2209_1 lab=net17}
N 313 41560 293 41560 {lab=clknet_3_0__leaf_clk}
C {./lab_pin.sym} 293 41560 0 0 {name=l2209_2 lab=clknet_3_0__leaf_clk}
N 313 41580 293 41580 {lab=u_clock_div_counter_b5}
C {./lab_pin.sym} 293 41580 0 0 {name=l2209_3 lab=u_clock_div_counter_b5}
N 497 41520 517 41520 {lab=VDD}
C {./lab_pin.sym} 517 41520 0 1 {name=l2209_4 lab=VDD}
N 497 41540 517 41540 {lab=VDD}
C {./lab_pin.sym} 517 41540 0 1 {name=l2209_5 lab=VDD}
N 497 41560 517 41560 {lab=VSS}
C {./lab_pin.sym} 517 41560 0 1 {name=l2209_6 lab=VSS}
N 497 41580 517 41580 {lab=VSS}
C {./lab_pin.sym} 517 41580 0 1 {name=l2209_7 lab=VSS}
C {./dffrnq_1.sym} 810 41550 0 0 {name=Xn_2151}
N 718 41520 698 41520 {lab=n_0143}
C {./lab_pin.sym} 698 41520 0 0 {name=l2210_0 lab=n_0143}
N 718 41540 698 41540 {lab=net17}
C {./lab_pin.sym} 698 41540 0 0 {name=l2210_1 lab=net17}
N 718 41560 698 41560 {lab=clknet_3_0__leaf_clk}
C {./lab_pin.sym} 698 41560 0 0 {name=l2210_2 lab=clknet_3_0__leaf_clk}
N 718 41580 698 41580 {lab=u_clock_div_counter_b6}
C {./lab_pin.sym} 698 41580 0 0 {name=l2210_3 lab=u_clock_div_counter_b6}
N 902 41520 922 41520 {lab=VDD}
C {./lab_pin.sym} 922 41520 0 1 {name=l2210_4 lab=VDD}
N 902 41540 922 41540 {lab=VDD}
C {./lab_pin.sym} 922 41540 0 1 {name=l2210_5 lab=VDD}
N 902 41560 922 41560 {lab=VSS}
C {./lab_pin.sym} 922 41560 0 1 {name=l2210_6 lab=VSS}
N 902 41580 922 41580 {lab=VSS}
C {./lab_pin.sym} 922 41580 0 1 {name=l2210_7 lab=VSS}
C {./dffrnq_2.sym} 1215 41550 0 0 {name=Xn_2152}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__dffrnq_2 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -50 72 -50 {}
L 4 72 -50 72 50 {}
L 4 72 50 -72 50 {}
L 4 -72 50 -72 -50 {}
T {@name} -72 -70 0 0 0.33 0.33 {}
T {dffrnq_2} -68 39 0 0 0.2 0.2 {}
L 4 -92 -30 -72 -30 {}
T {D} -66 -35 0 0 0.16 0.16 {}
L 4 -92 -10 -72 -10 {}
T {RN} -66 -15 0 0 0.16 0.16 {}
L 4 -92 10 -72 10 {}
T {CLK} -66 5 0 0 0.16 0.16 {}
L 4 -92 30 -72 30 {}
T {Q} -66 25 0 0 0.16 0.16 {}
L 4 92 -30 72 -30 {}
T {VDD} 50.2 -35 0 0 0.16 0.16 {}
L 4 92 -10 72 -10 {}
T {VNW} 50.2 -15 0 0 0.16 0.16 {}
L 4 92 10 72 10 {}
T {VPW} 50.2 5 0 0 0.16 0.16 {}
L 4 92 30 72 30 {}
T {VSS} 50.2 25 0 0 0.16 0.16 {}
B 5 -94 -32 -90 -28 {name=D dir=inout sim_pinnumber=1}
B 5 -94 -12 -90 -8 {name=RN dir=inout sim_pinnumber=2}
B 5 -94 8 -90 12 {name=CLK dir=inout sim_pinnumber=3}
B 5 -94 28 -90 32 {name=Q dir=inout sim_pinnumber=4}
B 5 90 -32 94 -28 {name=VDD dir=inout sim_pinnumber=5}
B 5 90 -12 94 -8 {name=VNW dir=inout sim_pinnumber=6}
B 5 90 8 94 12 {name=VPW dir=inout sim_pinnumber=7}
B 5 90 28 94 32 {name=VSS dir=inout sim_pinnumber=8}
]
N 1123 41520 1103 41520 {lab=n_0144}
C {./lab_pin.sym} 1103 41520 0 0 {name=l2211_0 lab=n_0144}
N 1123 41540 1103 41540 {lab=net21}
C {./lab_pin.sym} 1103 41540 0 0 {name=l2211_1 lab=net21}
N 1123 41560 1103 41560 {lab=clknet_3_2__leaf_clk}
C {./lab_pin.sym} 1103 41560 0 0 {name=l2211_2 lab=clknet_3_2__leaf_clk}
N 1123 41580 1103 41580 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 1103 41580 0 0 {name=l2211_3 lab=u_clock_div_counter_b7}
N 1307 41520 1327 41520 {lab=VDD}
C {./lab_pin.sym} 1327 41520 0 1 {name=l2211_4 lab=VDD}
N 1307 41540 1327 41540 {lab=VDD}
C {./lab_pin.sym} 1327 41540 0 1 {name=l2211_5 lab=VDD}
N 1307 41560 1327 41560 {lab=VSS}
C {./lab_pin.sym} 1327 41560 0 1 {name=l2211_6 lab=VSS}
N 1307 41580 1327 41580 {lab=VSS}
C {./lab_pin.sym} 1327 41580 0 1 {name=l2211_7 lab=VSS}
C {./dffnrnq_1.sym} 1620 41550 0 0 {name=Xn_2153}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__dffnrnq_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -50 72 -50 {}
L 4 72 -50 72 50 {}
L 4 72 50 -72 50 {}
L 4 -72 50 -72 -50 {}
T {@name} -72 -70 0 0 0.33 0.33 {}
T {dffnrnq_1} -68 39 0 0 0.2 0.2 {}
L 4 -92 -30 -72 -30 {}
T {D} -66 -35 0 0 0.16 0.16 {}
L 4 -92 -10 -72 -10 {}
T {RN} -66 -15 0 0 0.16 0.16 {}
L 4 -92 10 -72 10 {}
T {CLKN} -66 5 0 0 0.16 0.16 {}
L 4 -92 30 -72 30 {}
T {Q} -66 25 0 0 0.16 0.16 {}
L 4 92 -30 72 -30 {}
T {VDD} 50.2 -35 0 0 0.16 0.16 {}
L 4 92 -10 72 -10 {}
T {VNW} 50.2 -15 0 0 0.16 0.16 {}
L 4 92 10 72 10 {}
T {VPW} 50.2 5 0 0 0.16 0.16 {}
L 4 92 30 72 30 {}
T {VSS} 50.2 25 0 0 0.16 0.16 {}
B 5 -94 -32 -90 -28 {name=D dir=inout sim_pinnumber=1}
B 5 -94 -12 -90 -8 {name=RN dir=inout sim_pinnumber=2}
B 5 -94 8 -90 12 {name=CLKN dir=inout sim_pinnumber=3}
B 5 -94 28 -90 32 {name=Q dir=inout sim_pinnumber=4}
B 5 90 -32 94 -28 {name=VDD dir=inout sim_pinnumber=5}
B 5 90 -12 94 -8 {name=VNW dir=inout sim_pinnumber=6}
B 5 90 8 94 12 {name=VPW dir=inout sim_pinnumber=7}
B 5 90 28 94 32 {name=VSS dir=inout sim_pinnumber=8}
]
N 1528 41520 1508 41520 {lab=u_cas_diff_out_diff2_b0}
C {./lab_pin.sym} 1508 41520 0 0 {name=l2212_0 lab=u_cas_diff_out_diff2_b0}
N 1528 41540 1508 41540 {lab=net2}
C {./lab_pin.sym} 1508 41540 0 0 {name=l2212_1 lab=net2}
N 1528 41560 1508 41560 {lab=net16}
C {./lab_pin.sym} 1508 41560 0 0 {name=l2212_2 lab=net16}
N 1528 41580 1508 41580 {lab=u_cas_diff_u_diff3_in_min1_b0}
C {./lab_pin.sym} 1508 41580 0 0 {name=l2212_3 lab=u_cas_diff_u_diff3_in_min1_b0}
N 1712 41520 1732 41520 {lab=VDD}
C {./lab_pin.sym} 1732 41520 0 1 {name=l2212_4 lab=VDD}
N 1712 41540 1732 41540 {lab=VDD}
C {./lab_pin.sym} 1732 41540 0 1 {name=l2212_5 lab=VDD}
N 1712 41560 1732 41560 {lab=VSS}
C {./lab_pin.sym} 1732 41560 0 1 {name=l2212_6 lab=VSS}
N 1712 41580 1732 41580 {lab=VSS}
C {./lab_pin.sym} 1732 41580 0 1 {name=l2212_7 lab=VSS}
C {./dffnrnq_1.sym} 2025 41550 0 0 {name=Xn_2154}
N 1933 41520 1913 41520 {lab=u_cas_diff_out_diff2_b1}
C {./lab_pin.sym} 1913 41520 0 0 {name=l2213_0 lab=u_cas_diff_out_diff2_b1}
N 1933 41540 1913 41540 {lab=net2}
C {./lab_pin.sym} 1913 41540 0 0 {name=l2213_1 lab=net2}
N 1933 41560 1913 41560 {lab=net16}
C {./lab_pin.sym} 1913 41560 0 0 {name=l2213_2 lab=net16}
N 1933 41580 1913 41580 {lab=u_cas_diff_u_diff3_in_min1_b1}
C {./lab_pin.sym} 1913 41580 0 0 {name=l2213_3 lab=u_cas_diff_u_diff3_in_min1_b1}
N 2117 41520 2137 41520 {lab=VDD}
C {./lab_pin.sym} 2137 41520 0 1 {name=l2213_4 lab=VDD}
N 2117 41540 2137 41540 {lab=VDD}
C {./lab_pin.sym} 2137 41540 0 1 {name=l2213_5 lab=VDD}
N 2117 41560 2137 41560 {lab=VSS}
C {./lab_pin.sym} 2137 41560 0 1 {name=l2213_6 lab=VSS}
N 2117 41580 2137 41580 {lab=VSS}
C {./lab_pin.sym} 2137 41580 0 1 {name=l2213_7 lab=VSS}
C {./dffnrnq_1.sym} 2430 41550 0 0 {name=Xn_2155}
N 2338 41520 2318 41520 {lab=u_cas_diff_out_diff2_b2}
C {./lab_pin.sym} 2318 41520 0 0 {name=l2214_0 lab=u_cas_diff_out_diff2_b2}
N 2338 41540 2318 41540 {lab=net2}
C {./lab_pin.sym} 2318 41540 0 0 {name=l2214_1 lab=net2}
N 2338 41560 2318 41560 {lab=net16}
C {./lab_pin.sym} 2318 41560 0 0 {name=l2214_2 lab=net16}
N 2338 41580 2318 41580 {lab=u_cas_diff_u_diff3_in_min1_b2}
C {./lab_pin.sym} 2318 41580 0 0 {name=l2214_3 lab=u_cas_diff_u_diff3_in_min1_b2}
N 2522 41520 2542 41520 {lab=VDD}
C {./lab_pin.sym} 2542 41520 0 1 {name=l2214_4 lab=VDD}
N 2522 41540 2542 41540 {lab=VDD}
C {./lab_pin.sym} 2542 41540 0 1 {name=l2214_5 lab=VDD}
N 2522 41560 2542 41560 {lab=VSS}
C {./lab_pin.sym} 2542 41560 0 1 {name=l2214_6 lab=VSS}
N 2522 41580 2542 41580 {lab=VSS}
C {./lab_pin.sym} 2542 41580 0 1 {name=l2214_7 lab=VSS}
C {./dffnrnq_1.sym} 2835 41550 0 0 {name=Xn_2156}
N 2743 41520 2723 41520 {lab=u_cas_diff_out_diff2_b3}
C {./lab_pin.sym} 2723 41520 0 0 {name=l2215_0 lab=u_cas_diff_out_diff2_b3}
N 2743 41540 2723 41540 {lab=net2}
C {./lab_pin.sym} 2723 41540 0 0 {name=l2215_1 lab=net2}
N 2743 41560 2723 41560 {lab=net16}
C {./lab_pin.sym} 2723 41560 0 0 {name=l2215_2 lab=net16}
N 2743 41580 2723 41580 {lab=u_cas_diff_u_diff3_in_min1_b3}
C {./lab_pin.sym} 2723 41580 0 0 {name=l2215_3 lab=u_cas_diff_u_diff3_in_min1_b3}
N 2927 41520 2947 41520 {lab=VDD}
C {./lab_pin.sym} 2947 41520 0 1 {name=l2215_4 lab=VDD}
N 2927 41540 2947 41540 {lab=VDD}
C {./lab_pin.sym} 2947 41540 0 1 {name=l2215_5 lab=VDD}
N 2927 41560 2947 41560 {lab=VSS}
C {./lab_pin.sym} 2947 41560 0 1 {name=l2215_6 lab=VSS}
N 2927 41580 2947 41580 {lab=VSS}
C {./lab_pin.sym} 2947 41580 0 1 {name=l2215_7 lab=VSS}
C {./dffnrnq_1.sym} 3240 41550 0 0 {name=Xn_2157}
N 3148 41520 3128 41520 {lab=u_cas_diff_out_diff2_b4}
C {./lab_pin.sym} 3128 41520 0 0 {name=l2216_0 lab=u_cas_diff_out_diff2_b4}
N 3148 41540 3128 41540 {lab=net2}
C {./lab_pin.sym} 3128 41540 0 0 {name=l2216_1 lab=net2}
N 3148 41560 3128 41560 {lab=net16}
C {./lab_pin.sym} 3128 41560 0 0 {name=l2216_2 lab=net16}
N 3148 41580 3128 41580 {lab=u_cas_diff_u_diff3_in_min1_b4}
C {./lab_pin.sym} 3128 41580 0 0 {name=l2216_3 lab=u_cas_diff_u_diff3_in_min1_b4}
N 3332 41520 3352 41520 {lab=VDD}
C {./lab_pin.sym} 3352 41520 0 1 {name=l2216_4 lab=VDD}
N 3332 41540 3352 41540 {lab=VDD}
C {./lab_pin.sym} 3352 41540 0 1 {name=l2216_5 lab=VDD}
N 3332 41560 3352 41560 {lab=VSS}
C {./lab_pin.sym} 3352 41560 0 1 {name=l2216_6 lab=VSS}
N 3332 41580 3352 41580 {lab=VSS}
C {./lab_pin.sym} 3352 41580 0 1 {name=l2216_7 lab=VSS}
C {./dffnrnq_1.sym} 3645 41550 0 0 {name=Xn_2158}
N 3553 41520 3533 41520 {lab=u_cas_diff_out_diff2_b5}
C {./lab_pin.sym} 3533 41520 0 0 {name=l2217_0 lab=u_cas_diff_out_diff2_b5}
N 3553 41540 3533 41540 {lab=net2}
C {./lab_pin.sym} 3533 41540 0 0 {name=l2217_1 lab=net2}
N 3553 41560 3533 41560 {lab=net16}
C {./lab_pin.sym} 3533 41560 0 0 {name=l2217_2 lab=net16}
N 3553 41580 3533 41580 {lab=u_cas_diff_u_diff3_in_min1_b5}
C {./lab_pin.sym} 3533 41580 0 0 {name=l2217_3 lab=u_cas_diff_u_diff3_in_min1_b5}
N 3737 41520 3757 41520 {lab=VDD}
C {./lab_pin.sym} 3757 41520 0 1 {name=l2217_4 lab=VDD}
N 3737 41540 3757 41540 {lab=VDD}
C {./lab_pin.sym} 3757 41540 0 1 {name=l2217_5 lab=VDD}
N 3737 41560 3757 41560 {lab=VSS}
C {./lab_pin.sym} 3757 41560 0 1 {name=l2217_6 lab=VSS}
N 3737 41580 3757 41580 {lab=VSS}
C {./lab_pin.sym} 3757 41580 0 1 {name=l2217_7 lab=VSS}
C {./dffnrnq_1.sym} 4050 41550 0 0 {name=Xn_2159}
N 3958 41520 3938 41520 {lab=u_cas_diff_out_diff2_b6}
C {./lab_pin.sym} 3938 41520 0 0 {name=l2218_0 lab=u_cas_diff_out_diff2_b6}
N 3958 41540 3938 41540 {lab=net2}
C {./lab_pin.sym} 3938 41540 0 0 {name=l2218_1 lab=net2}
N 3958 41560 3938 41560 {lab=net15}
C {./lab_pin.sym} 3938 41560 0 0 {name=l2218_2 lab=net15}
N 3958 41580 3938 41580 {lab=u_cas_diff_u_diff3_in_min1_b6}
C {./lab_pin.sym} 3938 41580 0 0 {name=l2218_3 lab=u_cas_diff_u_diff3_in_min1_b6}
N 4142 41520 4162 41520 {lab=VDD}
C {./lab_pin.sym} 4162 41520 0 1 {name=l2218_4 lab=VDD}
N 4142 41540 4162 41540 {lab=VDD}
C {./lab_pin.sym} 4162 41540 0 1 {name=l2218_5 lab=VDD}
N 4142 41560 4162 41560 {lab=VSS}
C {./lab_pin.sym} 4162 41560 0 1 {name=l2218_6 lab=VSS}
N 4142 41580 4162 41580 {lab=VSS}
C {./lab_pin.sym} 4162 41580 0 1 {name=l2218_7 lab=VSS}
C {./dffnrnq_1.sym} 4455 41550 0 0 {name=Xn_2160}
N 4363 41520 4343 41520 {lab=u_cas_diff_out_diff2_b7}
C {./lab_pin.sym} 4343 41520 0 0 {name=l2219_0 lab=u_cas_diff_out_diff2_b7}
N 4363 41540 4343 41540 {lab=net2}
C {./lab_pin.sym} 4343 41540 0 0 {name=l2219_1 lab=net2}
N 4363 41560 4343 41560 {lab=net15}
C {./lab_pin.sym} 4343 41560 0 0 {name=l2219_2 lab=net15}
N 4363 41580 4343 41580 {lab=u_cas_diff_u_diff3_in_min1_b7}
C {./lab_pin.sym} 4343 41580 0 0 {name=l2219_3 lab=u_cas_diff_u_diff3_in_min1_b7}
N 4547 41520 4567 41520 {lab=VDD}
C {./lab_pin.sym} 4567 41520 0 1 {name=l2219_4 lab=VDD}
N 4547 41540 4567 41540 {lab=VDD}
C {./lab_pin.sym} 4567 41540 0 1 {name=l2219_5 lab=VDD}
N 4547 41560 4567 41560 {lab=VSS}
C {./lab_pin.sym} 4567 41560 0 1 {name=l2219_6 lab=VSS}
N 4547 41580 4567 41580 {lab=VSS}
C {./lab_pin.sym} 4567 41580 0 1 {name=l2219_7 lab=VSS}
C {./dffnrnq_1.sym} 0 41775 0 0 {name=Xn_2161}
N -92 41745 -112 41745 {lab=u_cas_diff_out_diff2_b8}
C {./lab_pin.sym} -112 41745 0 0 {name=l2220_0 lab=u_cas_diff_out_diff2_b8}
N -92 41765 -112 41765 {lab=net20}
C {./lab_pin.sym} -112 41765 0 0 {name=l2220_1 lab=net20}
N -92 41785 -112 41785 {lab=net15}
C {./lab_pin.sym} -112 41785 0 0 {name=l2220_2 lab=net15}
N -92 41805 -112 41805 {lab=u_cas_diff_u_diff3_in_min1_b8}
C {./lab_pin.sym} -112 41805 0 0 {name=l2220_3 lab=u_cas_diff_u_diff3_in_min1_b8}
N 92 41745 112 41745 {lab=VDD}
C {./lab_pin.sym} 112 41745 0 1 {name=l2220_4 lab=VDD}
N 92 41765 112 41765 {lab=VDD}
C {./lab_pin.sym} 112 41765 0 1 {name=l2220_5 lab=VDD}
N 92 41785 112 41785 {lab=VSS}
C {./lab_pin.sym} 112 41785 0 1 {name=l2220_6 lab=VSS}
N 92 41805 112 41805 {lab=VSS}
C {./lab_pin.sym} 112 41805 0 1 {name=l2220_7 lab=VSS}
C {./dffnrnq_1.sym} 405 41775 0 0 {name=Xn_2162}
N 313 41745 293 41745 {lab=u_cas_diff_out_diff2_b9}
C {./lab_pin.sym} 293 41745 0 0 {name=l2221_0 lab=u_cas_diff_out_diff2_b9}
N 313 41765 293 41765 {lab=net20}
C {./lab_pin.sym} 293 41765 0 0 {name=l2221_1 lab=net20}
N 313 41785 293 41785 {lab=net15}
C {./lab_pin.sym} 293 41785 0 0 {name=l2221_2 lab=net15}
N 313 41805 293 41805 {lab=u_cas_diff_u_diff3_in_min1_b9}
C {./lab_pin.sym} 293 41805 0 0 {name=l2221_3 lab=u_cas_diff_u_diff3_in_min1_b9}
N 497 41745 517 41745 {lab=VDD}
C {./lab_pin.sym} 517 41745 0 1 {name=l2221_4 lab=VDD}
N 497 41765 517 41765 {lab=VDD}
C {./lab_pin.sym} 517 41765 0 1 {name=l2221_5 lab=VDD}
N 497 41785 517 41785 {lab=VSS}
C {./lab_pin.sym} 517 41785 0 1 {name=l2221_6 lab=VSS}
N 497 41805 517 41805 {lab=VSS}
C {./lab_pin.sym} 517 41805 0 1 {name=l2221_7 lab=VSS}
C {./dffnrnq_1.sym} 810 41775 0 0 {name=Xn_2163}
N 718 41745 698 41745 {lab=u_cas_diff_out_diff2_b10}
C {./lab_pin.sym} 698 41745 0 0 {name=l2222_0 lab=u_cas_diff_out_diff2_b10}
N 718 41765 698 41765 {lab=net2}
C {./lab_pin.sym} 698 41765 0 0 {name=l2222_1 lab=net2}
N 718 41785 698 41785 {lab=net15}
C {./lab_pin.sym} 698 41785 0 0 {name=l2222_2 lab=net15}
N 718 41805 698 41805 {lab=u_cas_diff_u_diff3_in_min1_b10}
C {./lab_pin.sym} 698 41805 0 0 {name=l2222_3 lab=u_cas_diff_u_diff3_in_min1_b10}
N 902 41745 922 41745 {lab=VDD}
C {./lab_pin.sym} 922 41745 0 1 {name=l2222_4 lab=VDD}
N 902 41765 922 41765 {lab=VDD}
C {./lab_pin.sym} 922 41765 0 1 {name=l2222_5 lab=VDD}
N 902 41785 922 41785 {lab=VSS}
C {./lab_pin.sym} 922 41785 0 1 {name=l2222_6 lab=VSS}
N 902 41805 922 41805 {lab=VSS}
C {./lab_pin.sym} 922 41805 0 1 {name=l2222_7 lab=VSS}
C {./dffnrnq_1.sym} 1215 41775 0 0 {name=Xn_2164}
N 1123 41745 1103 41745 {lab=u_cas_diff_out_diff2_b11}
C {./lab_pin.sym} 1103 41745 0 0 {name=l2223_0 lab=u_cas_diff_out_diff2_b11}
N 1123 41765 1103 41765 {lab=net20}
C {./lab_pin.sym} 1103 41765 0 0 {name=l2223_1 lab=net20}
N 1123 41785 1103 41785 {lab=net15}
C {./lab_pin.sym} 1103 41785 0 0 {name=l2223_2 lab=net15}
N 1123 41805 1103 41805 {lab=u_cas_diff_u_diff3_in_min1_b11}
C {./lab_pin.sym} 1103 41805 0 0 {name=l2223_3 lab=u_cas_diff_u_diff3_in_min1_b11}
N 1307 41745 1327 41745 {lab=VDD}
C {./lab_pin.sym} 1327 41745 0 1 {name=l2223_4 lab=VDD}
N 1307 41765 1327 41765 {lab=VDD}
C {./lab_pin.sym} 1327 41765 0 1 {name=l2223_5 lab=VDD}
N 1307 41785 1327 41785 {lab=VSS}
C {./lab_pin.sym} 1327 41785 0 1 {name=l2223_6 lab=VSS}
N 1307 41805 1327 41805 {lab=VSS}
C {./lab_pin.sym} 1327 41805 0 1 {name=l2223_7 lab=VSS}
C {./dffnrnq_1.sym} 1620 41775 0 0 {name=Xn_2165}
N 1528 41745 1508 41745 {lab=u_cas_diff_out_diff2_b12}
C {./lab_pin.sym} 1508 41745 0 0 {name=l2224_0 lab=u_cas_diff_out_diff2_b12}
N 1528 41765 1508 41765 {lab=net20}
C {./lab_pin.sym} 1508 41765 0 0 {name=l2224_1 lab=net20}
N 1528 41785 1508 41785 {lab=net15}
C {./lab_pin.sym} 1508 41785 0 0 {name=l2224_2 lab=net15}
N 1528 41805 1508 41805 {lab=u_cas_diff_u_diff3_in_min1_b12}
C {./lab_pin.sym} 1508 41805 0 0 {name=l2224_3 lab=u_cas_diff_u_diff3_in_min1_b12}
N 1712 41745 1732 41745 {lab=VDD}
C {./lab_pin.sym} 1732 41745 0 1 {name=l2224_4 lab=VDD}
N 1712 41765 1732 41765 {lab=VDD}
C {./lab_pin.sym} 1732 41765 0 1 {name=l2224_5 lab=VDD}
N 1712 41785 1732 41785 {lab=VSS}
C {./lab_pin.sym} 1732 41785 0 1 {name=l2224_6 lab=VSS}
N 1712 41805 1732 41805 {lab=VSS}
C {./lab_pin.sym} 1732 41805 0 1 {name=l2224_7 lab=VSS}
C {./dffnrnq_1.sym} 2025 41775 0 0 {name=Xn_2166}
N 1933 41745 1913 41745 {lab=u_cas_diff_out_diff2_b13}
C {./lab_pin.sym} 1913 41745 0 0 {name=l2225_0 lab=u_cas_diff_out_diff2_b13}
N 1933 41765 1913 41765 {lab=net20}
C {./lab_pin.sym} 1913 41765 0 0 {name=l2225_1 lab=net20}
N 1933 41785 1913 41785 {lab=net15}
C {./lab_pin.sym} 1913 41785 0 0 {name=l2225_2 lab=net15}
N 1933 41805 1913 41805 {lab=u_cas_diff_u_diff3_in_min1_b13}
C {./lab_pin.sym} 1913 41805 0 0 {name=l2225_3 lab=u_cas_diff_u_diff3_in_min1_b13}
N 2117 41745 2137 41745 {lab=VDD}
C {./lab_pin.sym} 2137 41745 0 1 {name=l2225_4 lab=VDD}
N 2117 41765 2137 41765 {lab=VDD}
C {./lab_pin.sym} 2137 41765 0 1 {name=l2225_5 lab=VDD}
N 2117 41785 2137 41785 {lab=VSS}
C {./lab_pin.sym} 2137 41785 0 1 {name=l2225_6 lab=VSS}
N 2117 41805 2137 41805 {lab=VSS}
C {./lab_pin.sym} 2137 41805 0 1 {name=l2225_7 lab=VSS}
C {./dffnrnq_1.sym} 2430 41775 0 0 {name=Xn_2167}
N 2338 41745 2318 41745 {lab=u_cas_diff_out_diff2_b14}
C {./lab_pin.sym} 2318 41745 0 0 {name=l2226_0 lab=u_cas_diff_out_diff2_b14}
N 2338 41765 2318 41765 {lab=net20}
C {./lab_pin.sym} 2318 41765 0 0 {name=l2226_1 lab=net20}
N 2338 41785 2318 41785 {lab=net15}
C {./lab_pin.sym} 2318 41785 0 0 {name=l2226_2 lab=net15}
N 2338 41805 2318 41805 {lab=u_cas_diff_u_diff3_in_min1_b14}
C {./lab_pin.sym} 2318 41805 0 0 {name=l2226_3 lab=u_cas_diff_u_diff3_in_min1_b14}
N 2522 41745 2542 41745 {lab=VDD}
C {./lab_pin.sym} 2542 41745 0 1 {name=l2226_4 lab=VDD}
N 2522 41765 2542 41765 {lab=VDD}
C {./lab_pin.sym} 2542 41765 0 1 {name=l2226_5 lab=VDD}
N 2522 41785 2542 41785 {lab=VSS}
C {./lab_pin.sym} 2542 41785 0 1 {name=l2226_6 lab=VSS}
N 2522 41805 2542 41805 {lab=VSS}
C {./lab_pin.sym} 2542 41805 0 1 {name=l2226_7 lab=VSS}
C {./dffnrnq_1.sym} 2835 41775 0 0 {name=Xn_2168}
N 2743 41745 2723 41745 {lab=u_cas_diff_out_diff2_b15}
C {./lab_pin.sym} 2723 41745 0 0 {name=l2227_0 lab=u_cas_diff_out_diff2_b15}
N 2743 41765 2723 41765 {lab=net20}
C {./lab_pin.sym} 2723 41765 0 0 {name=l2227_1 lab=net20}
N 2743 41785 2723 41785 {lab=net15}
C {./lab_pin.sym} 2723 41785 0 0 {name=l2227_2 lab=net15}
N 2743 41805 2723 41805 {lab=u_cas_diff_u_diff3_in_min1_b15}
C {./lab_pin.sym} 2723 41805 0 0 {name=l2227_3 lab=u_cas_diff_u_diff3_in_min1_b15}
N 2927 41745 2947 41745 {lab=VDD}
C {./lab_pin.sym} 2947 41745 0 1 {name=l2227_4 lab=VDD}
N 2927 41765 2947 41765 {lab=VDD}
C {./lab_pin.sym} 2947 41765 0 1 {name=l2227_5 lab=VDD}
N 2927 41785 2947 41785 {lab=VSS}
C {./lab_pin.sym} 2947 41785 0 1 {name=l2227_6 lab=VSS}
N 2927 41805 2947 41805 {lab=VSS}
C {./lab_pin.sym} 2947 41805 0 1 {name=l2227_7 lab=VSS}
C {./dffnrnq_1.sym} 3240 41775 0 0 {name=Xn_2169}
N 3148 41745 3128 41745 {lab=u_cas_diff_out_diff2_b16}
C {./lab_pin.sym} 3128 41745 0 0 {name=l2228_0 lab=u_cas_diff_out_diff2_b16}
N 3148 41765 3128 41765 {lab=net20}
C {./lab_pin.sym} 3128 41765 0 0 {name=l2228_1 lab=net20}
N 3148 41785 3128 41785 {lab=net15}
C {./lab_pin.sym} 3128 41785 0 0 {name=l2228_2 lab=net15}
N 3148 41805 3128 41805 {lab=u_cas_diff_u_diff3_in_min1_b16}
C {./lab_pin.sym} 3128 41805 0 0 {name=l2228_3 lab=u_cas_diff_u_diff3_in_min1_b16}
N 3332 41745 3352 41745 {lab=VDD}
C {./lab_pin.sym} 3352 41745 0 1 {name=l2228_4 lab=VDD}
N 3332 41765 3352 41765 {lab=VDD}
C {./lab_pin.sym} 3352 41765 0 1 {name=l2228_5 lab=VDD}
N 3332 41785 3352 41785 {lab=VSS}
C {./lab_pin.sym} 3352 41785 0 1 {name=l2228_6 lab=VSS}
N 3332 41805 3352 41805 {lab=VSS}
C {./lab_pin.sym} 3352 41805 0 1 {name=l2228_7 lab=VSS}
C {./dffnrnq_1.sym} 3645 41775 0 0 {name=Xn_2170}
N 3553 41745 3533 41745 {lab=u_cas_diff_out_diff2_b17}
C {./lab_pin.sym} 3533 41745 0 0 {name=l2229_0 lab=u_cas_diff_out_diff2_b17}
N 3553 41765 3533 41765 {lab=net20}
C {./lab_pin.sym} 3533 41765 0 0 {name=l2229_1 lab=net20}
N 3553 41785 3533 41785 {lab=net15}
C {./lab_pin.sym} 3533 41785 0 0 {name=l2229_2 lab=net15}
N 3553 41805 3533 41805 {lab=u_cas_diff_u_diff3_in_min1_b17}
C {./lab_pin.sym} 3533 41805 0 0 {name=l2229_3 lab=u_cas_diff_u_diff3_in_min1_b17}
N 3737 41745 3757 41745 {lab=VDD}
C {./lab_pin.sym} 3757 41745 0 1 {name=l2229_4 lab=VDD}
N 3737 41765 3757 41765 {lab=VDD}
C {./lab_pin.sym} 3757 41765 0 1 {name=l2229_5 lab=VDD}
N 3737 41785 3757 41785 {lab=VSS}
C {./lab_pin.sym} 3757 41785 0 1 {name=l2229_6 lab=VSS}
N 3737 41805 3757 41805 {lab=VSS}
C {./lab_pin.sym} 3757 41805 0 1 {name=l2229_7 lab=VSS}
C {./dffnrnq_1.sym} 4050 41775 0 0 {name=Xn_2171}
N 3958 41745 3938 41745 {lab=u_cas_diff_out_diff2_b18}
C {./lab_pin.sym} 3938 41745 0 0 {name=l2230_0 lab=u_cas_diff_out_diff2_b18}
N 3958 41765 3938 41765 {lab=net20}
C {./lab_pin.sym} 3938 41765 0 0 {name=l2230_1 lab=net20}
N 3958 41785 3938 41785 {lab=net15}
C {./lab_pin.sym} 3938 41785 0 0 {name=l2230_2 lab=net15}
N 3958 41805 3938 41805 {lab=u_cas_diff_u_diff3_in_min1_b18}
C {./lab_pin.sym} 3938 41805 0 0 {name=l2230_3 lab=u_cas_diff_u_diff3_in_min1_b18}
N 4142 41745 4162 41745 {lab=VDD}
C {./lab_pin.sym} 4162 41745 0 1 {name=l2230_4 lab=VDD}
N 4142 41765 4162 41765 {lab=VDD}
C {./lab_pin.sym} 4162 41765 0 1 {name=l2230_5 lab=VDD}
N 4142 41785 4162 41785 {lab=VSS}
C {./lab_pin.sym} 4162 41785 0 1 {name=l2230_6 lab=VSS}
N 4142 41805 4162 41805 {lab=VSS}
C {./lab_pin.sym} 4162 41805 0 1 {name=l2230_7 lab=VSS}
C {./dffnrnq_1.sym} 4455 41775 0 0 {name=Xn_2172}
N 4363 41745 4343 41745 {lab=u_cas_diff_out_diff2_b19}
C {./lab_pin.sym} 4343 41745 0 0 {name=l2231_0 lab=u_cas_diff_out_diff2_b19}
N 4363 41765 4343 41765 {lab=net2}
C {./lab_pin.sym} 4343 41765 0 0 {name=l2231_1 lab=net2}
N 4363 41785 4343 41785 {lab=net15}
C {./lab_pin.sym} 4343 41785 0 0 {name=l2231_2 lab=net15}
N 4363 41805 4343 41805 {lab=u_cas_diff_u_diff3_in_min1_b19}
C {./lab_pin.sym} 4343 41805 0 0 {name=l2231_3 lab=u_cas_diff_u_diff3_in_min1_b19}
N 4547 41745 4567 41745 {lab=VDD}
C {./lab_pin.sym} 4567 41745 0 1 {name=l2231_4 lab=VDD}
N 4547 41765 4567 41765 {lab=VDD}
C {./lab_pin.sym} 4567 41765 0 1 {name=l2231_5 lab=VDD}
N 4547 41785 4567 41785 {lab=VSS}
C {./lab_pin.sym} 4567 41785 0 1 {name=l2231_6 lab=VSS}
N 4547 41805 4567 41805 {lab=VSS}
C {./lab_pin.sym} 4567 41805 0 1 {name=l2231_7 lab=VSS}
C {./dffnrnq_1.sym} 0 42000 0 0 {name=Xn_2173}
N -92 41970 -112 41970 {lab=u_cas_diff_out_diff2_b20}
C {./lab_pin.sym} -112 41970 0 0 {name=l2232_0 lab=u_cas_diff_out_diff2_b20}
N -92 41990 -112 41990 {lab=net20}
C {./lab_pin.sym} -112 41990 0 0 {name=l2232_1 lab=net20}
N -92 42010 -112 42010 {lab=net15}
C {./lab_pin.sym} -112 42010 0 0 {name=l2232_2 lab=net15}
N -92 42030 -112 42030 {lab=u_cas_diff_u_diff3_in_min1_b20}
C {./lab_pin.sym} -112 42030 0 0 {name=l2232_3 lab=u_cas_diff_u_diff3_in_min1_b20}
N 92 41970 112 41970 {lab=VDD}
C {./lab_pin.sym} 112 41970 0 1 {name=l2232_4 lab=VDD}
N 92 41990 112 41990 {lab=VDD}
C {./lab_pin.sym} 112 41990 0 1 {name=l2232_5 lab=VDD}
N 92 42010 112 42010 {lab=VSS}
C {./lab_pin.sym} 112 42010 0 1 {name=l2232_6 lab=VSS}
N 92 42030 112 42030 {lab=VSS}
C {./lab_pin.sym} 112 42030 0 1 {name=l2232_7 lab=VSS}
C {./dffnrnq_1.sym} 405 42000 0 0 {name=Xn_2174}
N 313 41970 293 41970 {lab=u_cas_diff_out_diff2_b21}
C {./lab_pin.sym} 293 41970 0 0 {name=l2233_0 lab=u_cas_diff_out_diff2_b21}
N 313 41990 293 41990 {lab=net20}
C {./lab_pin.sym} 293 41990 0 0 {name=l2233_1 lab=net20}
N 313 42010 293 42010 {lab=net15}
C {./lab_pin.sym} 293 42010 0 0 {name=l2233_2 lab=net15}
N 313 42030 293 42030 {lab=u_cas_diff_u_diff3_in_min1_b21}
C {./lab_pin.sym} 293 42030 0 0 {name=l2233_3 lab=u_cas_diff_u_diff3_in_min1_b21}
N 497 41970 517 41970 {lab=VDD}
C {./lab_pin.sym} 517 41970 0 1 {name=l2233_4 lab=VDD}
N 497 41990 517 41990 {lab=VDD}
C {./lab_pin.sym} 517 41990 0 1 {name=l2233_5 lab=VDD}
N 497 42010 517 42010 {lab=VSS}
C {./lab_pin.sym} 517 42010 0 1 {name=l2233_6 lab=VSS}
N 497 42030 517 42030 {lab=VSS}
C {./lab_pin.sym} 517 42030 0 1 {name=l2233_7 lab=VSS}
C {./dffnrnq_1.sym} 810 42000 0 0 {name=Xn_2175}
N 718 41970 698 41970 {lab=u_cas_diff_out_diff2_b22}
C {./lab_pin.sym} 698 41970 0 0 {name=l2234_0 lab=u_cas_diff_out_diff2_b22}
N 718 41990 698 41990 {lab=net20}
C {./lab_pin.sym} 698 41990 0 0 {name=l2234_1 lab=net20}
N 718 42010 698 42010 {lab=net15}
C {./lab_pin.sym} 698 42010 0 0 {name=l2234_2 lab=net15}
N 718 42030 698 42030 {lab=u_cas_diff_u_diff3_in_min1_b22}
C {./lab_pin.sym} 698 42030 0 0 {name=l2234_3 lab=u_cas_diff_u_diff3_in_min1_b22}
N 902 41970 922 41970 {lab=VDD}
C {./lab_pin.sym} 922 41970 0 1 {name=l2234_4 lab=VDD}
N 902 41990 922 41990 {lab=VDD}
C {./lab_pin.sym} 922 41990 0 1 {name=l2234_5 lab=VDD}
N 902 42010 922 42010 {lab=VSS}
C {./lab_pin.sym} 922 42010 0 1 {name=l2234_6 lab=VSS}
N 902 42030 922 42030 {lab=VSS}
C {./lab_pin.sym} 922 42030 0 1 {name=l2234_7 lab=VSS}
C {./dffnrnq_1.sym} 1215 42000 0 0 {name=Xn_2176}
N 1123 41970 1103 41970 {lab=u_cas_diff_out_diff2_b23}
C {./lab_pin.sym} 1103 41970 0 0 {name=l2235_0 lab=u_cas_diff_out_diff2_b23}
N 1123 41990 1103 41990 {lab=net20}
C {./lab_pin.sym} 1103 41990 0 0 {name=l2235_1 lab=net20}
N 1123 42010 1103 42010 {lab=net15}
C {./lab_pin.sym} 1103 42010 0 0 {name=l2235_2 lab=net15}
N 1123 42030 1103 42030 {lab=u_cas_diff_u_diff3_in_min1_b23}
C {./lab_pin.sym} 1103 42030 0 0 {name=l2235_3 lab=u_cas_diff_u_diff3_in_min1_b23}
N 1307 41970 1327 41970 {lab=VDD}
C {./lab_pin.sym} 1327 41970 0 1 {name=l2235_4 lab=VDD}
N 1307 41990 1327 41990 {lab=VDD}
C {./lab_pin.sym} 1327 41990 0 1 {name=l2235_5 lab=VDD}
N 1307 42010 1327 42010 {lab=VSS}
C {./lab_pin.sym} 1327 42010 0 1 {name=l2235_6 lab=VSS}
N 1307 42030 1327 42030 {lab=VSS}
C {./lab_pin.sym} 1327 42030 0 1 {name=l2235_7 lab=VSS}
C {./dffnrnq_1.sym} 1620 42000 0 0 {name=Xn_2177}
N 1528 41970 1508 41970 {lab=u_cas_diff_out_diff2_b24}
C {./lab_pin.sym} 1508 41970 0 0 {name=l2236_0 lab=u_cas_diff_out_diff2_b24}
N 1528 41990 1508 41990 {lab=net20}
C {./lab_pin.sym} 1508 41990 0 0 {name=l2236_1 lab=net20}
N 1528 42010 1508 42010 {lab=net15}
C {./lab_pin.sym} 1508 42010 0 0 {name=l2236_2 lab=net15}
N 1528 42030 1508 42030 {lab=u_cas_diff_u_diff3_in_min1_b24}
C {./lab_pin.sym} 1508 42030 0 0 {name=l2236_3 lab=u_cas_diff_u_diff3_in_min1_b24}
N 1712 41970 1732 41970 {lab=VDD}
C {./lab_pin.sym} 1732 41970 0 1 {name=l2236_4 lab=VDD}
N 1712 41990 1732 41990 {lab=VDD}
C {./lab_pin.sym} 1732 41990 0 1 {name=l2236_5 lab=VDD}
N 1712 42010 1732 42010 {lab=VSS}
C {./lab_pin.sym} 1732 42010 0 1 {name=l2236_6 lab=VSS}
N 1712 42030 1732 42030 {lab=VSS}
C {./lab_pin.sym} 1732 42030 0 1 {name=l2236_7 lab=VSS}
C {./dffnrnq_1.sym} 2025 42000 0 0 {name=Xn_2178}
N 1933 41970 1913 41970 {lab=n_0050}
C {./lab_pin.sym} 1913 41970 0 0 {name=l2237_0 lab=n_0050}
N 1933 41990 1913 41990 {lab=net2}
C {./lab_pin.sym} 1913 41990 0 0 {name=l2237_1 lab=net2}
N 1933 42010 1913 42010 {lab=net15}
C {./lab_pin.sym} 1913 42010 0 0 {name=l2237_2 lab=net15}
N 1933 42030 1913 42030 {lab=net3}
C {./lab_pin.sym} 1913 42030 0 0 {name=l2237_3 lab=net3}
N 2117 41970 2137 41970 {lab=VDD}
C {./lab_pin.sym} 2137 41970 0 1 {name=l2237_4 lab=VDD}
N 2117 41990 2137 41990 {lab=VDD}
C {./lab_pin.sym} 2137 41990 0 1 {name=l2237_5 lab=VDD}
N 2117 42010 2137 42010 {lab=VSS}
C {./lab_pin.sym} 2137 42010 0 1 {name=l2237_6 lab=VSS}
N 2117 42030 2137 42030 {lab=VSS}
C {./lab_pin.sym} 2137 42030 0 1 {name=l2237_7 lab=VSS}
C {./dffnrnq_1.sym} 2430 42000 0 0 {name=Xn_2179}
N 2338 41970 2318 41970 {lab=n_0051}
C {./lab_pin.sym} 2318 41970 0 0 {name=l2238_0 lab=n_0051}
N 2338 41990 2318 41990 {lab=net2}
C {./lab_pin.sym} 2318 41990 0 0 {name=l2238_1 lab=net2}
N 2338 42010 2318 42010 {lab=net15}
C {./lab_pin.sym} 2318 42010 0 0 {name=l2238_2 lab=net15}
N 2338 42030 2318 42030 {lab=net6}
C {./lab_pin.sym} 2318 42030 0 0 {name=l2238_3 lab=net6}
N 2522 41970 2542 41970 {lab=VDD}
C {./lab_pin.sym} 2542 41970 0 1 {name=l2238_4 lab=VDD}
N 2522 41990 2542 41990 {lab=VDD}
C {./lab_pin.sym} 2542 41990 0 1 {name=l2238_5 lab=VDD}
N 2522 42010 2542 42010 {lab=VSS}
C {./lab_pin.sym} 2542 42010 0 1 {name=l2238_6 lab=VSS}
N 2522 42030 2542 42030 {lab=VSS}
C {./lab_pin.sym} 2542 42030 0 1 {name=l2238_7 lab=VSS}
C {./dffnrnq_1.sym} 2835 42000 0 0 {name=Xn_2180}
N 2743 41970 2723 41970 {lab=n_0052}
C {./lab_pin.sym} 2723 41970 0 0 {name=l2239_0 lab=n_0052}
N 2743 41990 2723 41990 {lab=net2}
C {./lab_pin.sym} 2723 41990 0 0 {name=l2239_1 lab=net2}
N 2743 42010 2723 42010 {lab=net15}
C {./lab_pin.sym} 2723 42010 0 0 {name=l2239_2 lab=net15}
N 2743 42030 2723 42030 {lab=net7}
C {./lab_pin.sym} 2723 42030 0 0 {name=l2239_3 lab=net7}
N 2927 41970 2947 41970 {lab=VDD}
C {./lab_pin.sym} 2947 41970 0 1 {name=l2239_4 lab=VDD}
N 2927 41990 2947 41990 {lab=VDD}
C {./lab_pin.sym} 2947 41990 0 1 {name=l2239_5 lab=VDD}
N 2927 42010 2947 42010 {lab=VSS}
C {./lab_pin.sym} 2947 42010 0 1 {name=l2239_6 lab=VSS}
N 2927 42030 2947 42030 {lab=VSS}
C {./lab_pin.sym} 2947 42030 0 1 {name=l2239_7 lab=VSS}
C {./dffnrnq_1.sym} 3240 42000 0 0 {name=Xn_2181}
N 3148 41970 3128 41970 {lab=n_0053}
C {./lab_pin.sym} 3128 41970 0 0 {name=l2240_0 lab=n_0053}
N 3148 41990 3128 41990 {lab=net2}
C {./lab_pin.sym} 3128 41990 0 0 {name=l2240_1 lab=net2}
N 3148 42010 3128 42010 {lab=net15}
C {./lab_pin.sym} 3128 42010 0 0 {name=l2240_2 lab=net15}
N 3148 42030 3128 42030 {lab=net8}
C {./lab_pin.sym} 3128 42030 0 0 {name=l2240_3 lab=net8}
N 3332 41970 3352 41970 {lab=VDD}
C {./lab_pin.sym} 3352 41970 0 1 {name=l2240_4 lab=VDD}
N 3332 41990 3352 41990 {lab=VDD}
C {./lab_pin.sym} 3352 41990 0 1 {name=l2240_5 lab=VDD}
N 3332 42010 3352 42010 {lab=VSS}
C {./lab_pin.sym} 3352 42010 0 1 {name=l2240_6 lab=VSS}
N 3332 42030 3352 42030 {lab=VSS}
C {./lab_pin.sym} 3352 42030 0 1 {name=l2240_7 lab=VSS}
C {./dffnrnq_1.sym} 3645 42000 0 0 {name=Xn_2182}
N 3553 41970 3533 41970 {lab=n_0054}
C {./lab_pin.sym} 3533 41970 0 0 {name=l2241_0 lab=n_0054}
N 3553 41990 3533 41990 {lab=net2}
C {./lab_pin.sym} 3533 41990 0 0 {name=l2241_1 lab=net2}
N 3553 42010 3533 42010 {lab=net15}
C {./lab_pin.sym} 3533 42010 0 0 {name=l2241_2 lab=net15}
N 3553 42030 3533 42030 {lab=net9}
C {./lab_pin.sym} 3533 42030 0 0 {name=l2241_3 lab=net9}
N 3737 41970 3757 41970 {lab=VDD}
C {./lab_pin.sym} 3757 41970 0 1 {name=l2241_4 lab=VDD}
N 3737 41990 3757 41990 {lab=VDD}
C {./lab_pin.sym} 3757 41990 0 1 {name=l2241_5 lab=VDD}
N 3737 42010 3757 42010 {lab=VSS}
C {./lab_pin.sym} 3757 42010 0 1 {name=l2241_6 lab=VSS}
N 3737 42030 3757 42030 {lab=VSS}
C {./lab_pin.sym} 3757 42030 0 1 {name=l2241_7 lab=VSS}
C {./dffnrnq_1.sym} 4050 42000 0 0 {name=Xn_2183}
N 3958 41970 3938 41970 {lab=n_0055}
C {./lab_pin.sym} 3938 41970 0 0 {name=l2242_0 lab=n_0055}
N 3958 41990 3938 41990 {lab=net2}
C {./lab_pin.sym} 3938 41990 0 0 {name=l2242_1 lab=net2}
N 3958 42010 3938 42010 {lab=net15}
C {./lab_pin.sym} 3938 42010 0 0 {name=l2242_2 lab=net15}
N 3958 42030 3938 42030 {lab=net10}
C {./lab_pin.sym} 3938 42030 0 0 {name=l2242_3 lab=net10}
N 4142 41970 4162 41970 {lab=VDD}
C {./lab_pin.sym} 4162 41970 0 1 {name=l2242_4 lab=VDD}
N 4142 41990 4162 41990 {lab=VDD}
C {./lab_pin.sym} 4162 41990 0 1 {name=l2242_5 lab=VDD}
N 4142 42010 4162 42010 {lab=VSS}
C {./lab_pin.sym} 4162 42010 0 1 {name=l2242_6 lab=VSS}
N 4142 42030 4162 42030 {lab=VSS}
C {./lab_pin.sym} 4162 42030 0 1 {name=l2242_7 lab=VSS}
C {./dffnrnq_1.sym} 4455 42000 0 0 {name=Xn_2184}
N 4363 41970 4343 41970 {lab=n_0056}
C {./lab_pin.sym} 4343 41970 0 0 {name=l2243_0 lab=n_0056}
N 4363 41990 4343 41990 {lab=net2}
C {./lab_pin.sym} 4343 41990 0 0 {name=l2243_1 lab=net2}
N 4363 42010 4343 42010 {lab=net15}
C {./lab_pin.sym} 4343 42010 0 0 {name=l2243_2 lab=net15}
N 4363 42030 4343 42030 {lab=net11}
C {./lab_pin.sym} 4343 42030 0 0 {name=l2243_3 lab=net11}
N 4547 41970 4567 41970 {lab=VDD}
C {./lab_pin.sym} 4567 41970 0 1 {name=l2243_4 lab=VDD}
N 4547 41990 4567 41990 {lab=VDD}
C {./lab_pin.sym} 4567 41990 0 1 {name=l2243_5 lab=VDD}
N 4547 42010 4567 42010 {lab=VSS}
C {./lab_pin.sym} 4567 42010 0 1 {name=l2243_6 lab=VSS}
N 4547 42030 4567 42030 {lab=VSS}
C {./lab_pin.sym} 4567 42030 0 1 {name=l2243_7 lab=VSS}
C {./dffnrnq_1.sym} 0 42225 0 0 {name=Xn_2185}
N -92 42195 -112 42195 {lab=n_0057}
C {./lab_pin.sym} -112 42195 0 0 {name=l2244_0 lab=n_0057}
N -92 42215 -112 42215 {lab=net2}
C {./lab_pin.sym} -112 42215 0 0 {name=l2244_1 lab=net2}
N -92 42235 -112 42235 {lab=net15}
C {./lab_pin.sym} -112 42235 0 0 {name=l2244_2 lab=net15}
N -92 42255 -112 42255 {lab=net12}
C {./lab_pin.sym} -112 42255 0 0 {name=l2244_3 lab=net12}
N 92 42195 112 42195 {lab=VDD}
C {./lab_pin.sym} 112 42195 0 1 {name=l2244_4 lab=VDD}
N 92 42215 112 42215 {lab=VDD}
C {./lab_pin.sym} 112 42215 0 1 {name=l2244_5 lab=VDD}
N 92 42235 112 42235 {lab=VSS}
C {./lab_pin.sym} 112 42235 0 1 {name=l2244_6 lab=VSS}
N 92 42255 112 42255 {lab=VSS}
C {./lab_pin.sym} 112 42255 0 1 {name=l2244_7 lab=VSS}
C {./dffnrnq_1.sym} 405 42225 0 0 {name=Xn_2186}
N 313 42195 293 42195 {lab=n_0058}
C {./lab_pin.sym} 293 42195 0 0 {name=l2245_0 lab=n_0058}
N 313 42215 293 42215 {lab=net2}
C {./lab_pin.sym} 293 42215 0 0 {name=l2245_1 lab=net2}
N 313 42235 293 42235 {lab=net15}
C {./lab_pin.sym} 293 42235 0 0 {name=l2245_2 lab=net15}
N 313 42255 293 42255 {lab=net13}
C {./lab_pin.sym} 293 42255 0 0 {name=l2245_3 lab=net13}
N 497 42195 517 42195 {lab=VDD}
C {./lab_pin.sym} 517 42195 0 1 {name=l2245_4 lab=VDD}
N 497 42215 517 42215 {lab=VDD}
C {./lab_pin.sym} 517 42215 0 1 {name=l2245_5 lab=VDD}
N 497 42235 517 42235 {lab=VSS}
C {./lab_pin.sym} 517 42235 0 1 {name=l2245_6 lab=VSS}
N 497 42255 517 42255 {lab=VSS}
C {./lab_pin.sym} 517 42255 0 1 {name=l2245_7 lab=VSS}
C {./dffnrnq_1.sym} 810 42225 0 0 {name=Xn_2187}
N 718 42195 698 42195 {lab=n_0059}
C {./lab_pin.sym} 698 42195 0 0 {name=l2246_0 lab=n_0059}
N 718 42215 698 42215 {lab=net2}
C {./lab_pin.sym} 698 42215 0 0 {name=l2246_1 lab=net2}
N 718 42235 698 42235 {lab=net15}
C {./lab_pin.sym} 698 42235 0 0 {name=l2246_2 lab=net15}
N 718 42255 698 42255 {lab=net14}
C {./lab_pin.sym} 698 42255 0 0 {name=l2246_3 lab=net14}
N 902 42195 922 42195 {lab=VDD}
C {./lab_pin.sym} 922 42195 0 1 {name=l2246_4 lab=VDD}
N 902 42215 922 42215 {lab=VDD}
C {./lab_pin.sym} 922 42215 0 1 {name=l2246_5 lab=VDD}
N 902 42235 922 42235 {lab=VSS}
C {./lab_pin.sym} 922 42235 0 1 {name=l2246_6 lab=VSS}
N 902 42255 922 42255 {lab=VSS}
C {./lab_pin.sym} 922 42255 0 1 {name=l2246_7 lab=VSS}
C {./dffnrnq_1.sym} 1215 42225 0 0 {name=Xn_2188}
N 1123 42195 1103 42195 {lab=n_0060}
C {./lab_pin.sym} 1103 42195 0 0 {name=l2247_0 lab=n_0060}
N 1123 42215 1103 42215 {lab=net2}
C {./lab_pin.sym} 1103 42215 0 0 {name=l2247_1 lab=net2}
N 1123 42235 1103 42235 {lab=net15}
C {./lab_pin.sym} 1103 42235 0 0 {name=l2247_2 lab=net15}
N 1123 42255 1103 42255 {lab=net4}
C {./lab_pin.sym} 1103 42255 0 0 {name=l2247_3 lab=net4}
N 1307 42195 1327 42195 {lab=VDD}
C {./lab_pin.sym} 1327 42195 0 1 {name=l2247_4 lab=VDD}
N 1307 42215 1327 42215 {lab=VDD}
C {./lab_pin.sym} 1327 42215 0 1 {name=l2247_5 lab=VDD}
N 1307 42235 1327 42235 {lab=VSS}
C {./lab_pin.sym} 1327 42235 0 1 {name=l2247_6 lab=VSS}
N 1307 42255 1327 42255 {lab=VSS}
C {./lab_pin.sym} 1327 42255 0 1 {name=l2247_7 lab=VSS}
C {./dffnrnq_1.sym} 1620 42225 0 0 {name=Xn_2189}
N 1528 42195 1508 42195 {lab=n_0061}
C {./lab_pin.sym} 1508 42195 0 0 {name=l2248_0 lab=n_0061}
N 1528 42215 1508 42215 {lab=net2}
C {./lab_pin.sym} 1508 42215 0 0 {name=l2248_1 lab=net2}
N 1528 42235 1508 42235 {lab=net15}
C {./lab_pin.sym} 1508 42235 0 0 {name=l2248_2 lab=net15}
N 1528 42255 1508 42255 {lab=net5}
C {./lab_pin.sym} 1508 42255 0 0 {name=l2248_3 lab=net5}
N 1712 42195 1732 42195 {lab=VDD}
C {./lab_pin.sym} 1732 42195 0 1 {name=l2248_4 lab=VDD}
N 1712 42215 1732 42215 {lab=VDD}
C {./lab_pin.sym} 1732 42215 0 1 {name=l2248_5 lab=VDD}
N 1712 42235 1732 42235 {lab=VSS}
C {./lab_pin.sym} 1732 42235 0 1 {name=l2248_6 lab=VSS}
N 1712 42255 1732 42255 {lab=VSS}
C {./lab_pin.sym} 1732 42255 0 1 {name=l2248_7 lab=VSS}
C {./dffnrnq_1.sym} 2025 42225 0 0 {name=Xn_2190}
N 1933 42195 1913 42195 {lab=u_cas_diff_out_diff1_b0}
C {./lab_pin.sym} 1913 42195 0 0 {name=l2249_0 lab=u_cas_diff_out_diff1_b0}
N 1933 42215 1913 42215 {lab=net21}
C {./lab_pin.sym} 1913 42215 0 0 {name=l2249_1 lab=net21}
N 1933 42235 1913 42235 {lab=net16}
C {./lab_pin.sym} 1913 42235 0 0 {name=l2249_2 lab=net16}
N 1933 42255 1913 42255 {lab=u_cas_diff_u_diff2_in_min1_b0}
C {./lab_pin.sym} 1913 42255 0 0 {name=l2249_3 lab=u_cas_diff_u_diff2_in_min1_b0}
N 2117 42195 2137 42195 {lab=VDD}
C {./lab_pin.sym} 2137 42195 0 1 {name=l2249_4 lab=VDD}
N 2117 42215 2137 42215 {lab=VDD}
C {./lab_pin.sym} 2137 42215 0 1 {name=l2249_5 lab=VDD}
N 2117 42235 2137 42235 {lab=VSS}
C {./lab_pin.sym} 2137 42235 0 1 {name=l2249_6 lab=VSS}
N 2117 42255 2137 42255 {lab=VSS}
C {./lab_pin.sym} 2137 42255 0 1 {name=l2249_7 lab=VSS}
C {./dffnrnq_1.sym} 2430 42225 0 0 {name=Xn_2191}
N 2338 42195 2318 42195 {lab=u_cas_diff_out_diff1_b1}
C {./lab_pin.sym} 2318 42195 0 0 {name=l2250_0 lab=u_cas_diff_out_diff1_b1}
N 2338 42215 2318 42215 {lab=net21}
C {./lab_pin.sym} 2318 42215 0 0 {name=l2250_1 lab=net21}
N 2338 42235 2318 42235 {lab=net16}
C {./lab_pin.sym} 2318 42235 0 0 {name=l2250_2 lab=net16}
N 2338 42255 2318 42255 {lab=u_cas_diff_u_diff2_in_min1_b1}
C {./lab_pin.sym} 2318 42255 0 0 {name=l2250_3 lab=u_cas_diff_u_diff2_in_min1_b1}
N 2522 42195 2542 42195 {lab=VDD}
C {./lab_pin.sym} 2542 42195 0 1 {name=l2250_4 lab=VDD}
N 2522 42215 2542 42215 {lab=VDD}
C {./lab_pin.sym} 2542 42215 0 1 {name=l2250_5 lab=VDD}
N 2522 42235 2542 42235 {lab=VSS}
C {./lab_pin.sym} 2542 42235 0 1 {name=l2250_6 lab=VSS}
N 2522 42255 2542 42255 {lab=VSS}
C {./lab_pin.sym} 2542 42255 0 1 {name=l2250_7 lab=VSS}
C {./dffnrnq_1.sym} 2835 42225 0 0 {name=Xn_2192}
N 2743 42195 2723 42195 {lab=u_cas_diff_out_diff1_b2}
C {./lab_pin.sym} 2723 42195 0 0 {name=l2251_0 lab=u_cas_diff_out_diff1_b2}
N 2743 42215 2723 42215 {lab=net19}
C {./lab_pin.sym} 2723 42215 0 0 {name=l2251_1 lab=net19}
N 2743 42235 2723 42235 {lab=net16}
C {./lab_pin.sym} 2723 42235 0 0 {name=l2251_2 lab=net16}
N 2743 42255 2723 42255 {lab=u_cas_diff_u_diff2_in_min1_b2}
C {./lab_pin.sym} 2723 42255 0 0 {name=l2251_3 lab=u_cas_diff_u_diff2_in_min1_b2}
N 2927 42195 2947 42195 {lab=VDD}
C {./lab_pin.sym} 2947 42195 0 1 {name=l2251_4 lab=VDD}
N 2927 42215 2947 42215 {lab=VDD}
C {./lab_pin.sym} 2947 42215 0 1 {name=l2251_5 lab=VDD}
N 2927 42235 2947 42235 {lab=VSS}
C {./lab_pin.sym} 2947 42235 0 1 {name=l2251_6 lab=VSS}
N 2927 42255 2947 42255 {lab=VSS}
C {./lab_pin.sym} 2947 42255 0 1 {name=l2251_7 lab=VSS}
C {./dffnrnq_1.sym} 3240 42225 0 0 {name=Xn_2193}
N 3148 42195 3128 42195 {lab=u_cas_diff_out_diff1_b3}
C {./lab_pin.sym} 3128 42195 0 0 {name=l2252_0 lab=u_cas_diff_out_diff1_b3}
N 3148 42215 3128 42215 {lab=net19}
C {./lab_pin.sym} 3128 42215 0 0 {name=l2252_1 lab=net19}
N 3148 42235 3128 42235 {lab=net16}
C {./lab_pin.sym} 3128 42235 0 0 {name=l2252_2 lab=net16}
N 3148 42255 3128 42255 {lab=u_cas_diff_u_diff2_in_min1_b3}
C {./lab_pin.sym} 3128 42255 0 0 {name=l2252_3 lab=u_cas_diff_u_diff2_in_min1_b3}
N 3332 42195 3352 42195 {lab=VDD}
C {./lab_pin.sym} 3352 42195 0 1 {name=l2252_4 lab=VDD}
N 3332 42215 3352 42215 {lab=VDD}
C {./lab_pin.sym} 3352 42215 0 1 {name=l2252_5 lab=VDD}
N 3332 42235 3352 42235 {lab=VSS}
C {./lab_pin.sym} 3352 42235 0 1 {name=l2252_6 lab=VSS}
N 3332 42255 3352 42255 {lab=VSS}
C {./lab_pin.sym} 3352 42255 0 1 {name=l2252_7 lab=VSS}
C {./dffnrnq_1.sym} 3645 42225 0 0 {name=Xn_2194}
N 3553 42195 3533 42195 {lab=u_cas_diff_out_diff1_b4}
C {./lab_pin.sym} 3533 42195 0 0 {name=l2253_0 lab=u_cas_diff_out_diff1_b4}
N 3553 42215 3533 42215 {lab=net19}
C {./lab_pin.sym} 3533 42215 0 0 {name=l2253_1 lab=net19}
N 3553 42235 3533 42235 {lab=net16}
C {./lab_pin.sym} 3533 42235 0 0 {name=l2253_2 lab=net16}
N 3553 42255 3533 42255 {lab=u_cas_diff_u_diff2_in_min1_b4}
C {./lab_pin.sym} 3533 42255 0 0 {name=l2253_3 lab=u_cas_diff_u_diff2_in_min1_b4}
N 3737 42195 3757 42195 {lab=VDD}
C {./lab_pin.sym} 3757 42195 0 1 {name=l2253_4 lab=VDD}
N 3737 42215 3757 42215 {lab=VDD}
C {./lab_pin.sym} 3757 42215 0 1 {name=l2253_5 lab=VDD}
N 3737 42235 3757 42235 {lab=VSS}
C {./lab_pin.sym} 3757 42235 0 1 {name=l2253_6 lab=VSS}
N 3737 42255 3757 42255 {lab=VSS}
C {./lab_pin.sym} 3757 42255 0 1 {name=l2253_7 lab=VSS}
C {./dffnrnq_1.sym} 4050 42225 0 0 {name=Xn_2195}
N 3958 42195 3938 42195 {lab=u_cas_diff_out_diff1_b5}
C {./lab_pin.sym} 3938 42195 0 0 {name=l2254_0 lab=u_cas_diff_out_diff1_b5}
N 3958 42215 3938 42215 {lab=net19}
C {./lab_pin.sym} 3938 42215 0 0 {name=l2254_1 lab=net19}
N 3958 42235 3938 42235 {lab=net16}
C {./lab_pin.sym} 3938 42235 0 0 {name=l2254_2 lab=net16}
N 3958 42255 3938 42255 {lab=u_cas_diff_u_diff2_in_min1_b5}
C {./lab_pin.sym} 3938 42255 0 0 {name=l2254_3 lab=u_cas_diff_u_diff2_in_min1_b5}
N 4142 42195 4162 42195 {lab=VDD}
C {./lab_pin.sym} 4162 42195 0 1 {name=l2254_4 lab=VDD}
N 4142 42215 4162 42215 {lab=VDD}
C {./lab_pin.sym} 4162 42215 0 1 {name=l2254_5 lab=VDD}
N 4142 42235 4162 42235 {lab=VSS}
C {./lab_pin.sym} 4162 42235 0 1 {name=l2254_6 lab=VSS}
N 4142 42255 4162 42255 {lab=VSS}
C {./lab_pin.sym} 4162 42255 0 1 {name=l2254_7 lab=VSS}
C {./dffnrnq_1.sym} 4455 42225 0 0 {name=Xn_2196}
N 4363 42195 4343 42195 {lab=u_cas_diff_out_diff1_b6}
C {./lab_pin.sym} 4343 42195 0 0 {name=l2255_0 lab=u_cas_diff_out_diff1_b6}
N 4363 42215 4343 42215 {lab=net19}
C {./lab_pin.sym} 4343 42215 0 0 {name=l2255_1 lab=net19}
N 4363 42235 4343 42235 {lab=net16}
C {./lab_pin.sym} 4343 42235 0 0 {name=l2255_2 lab=net16}
N 4363 42255 4343 42255 {lab=u_cas_diff_u_diff2_in_min1_b6}
C {./lab_pin.sym} 4343 42255 0 0 {name=l2255_3 lab=u_cas_diff_u_diff2_in_min1_b6}
N 4547 42195 4567 42195 {lab=VDD}
C {./lab_pin.sym} 4567 42195 0 1 {name=l2255_4 lab=VDD}
N 4547 42215 4567 42215 {lab=VDD}
C {./lab_pin.sym} 4567 42215 0 1 {name=l2255_5 lab=VDD}
N 4547 42235 4567 42235 {lab=VSS}
C {./lab_pin.sym} 4567 42235 0 1 {name=l2255_6 lab=VSS}
N 4547 42255 4567 42255 {lab=VSS}
C {./lab_pin.sym} 4567 42255 0 1 {name=l2255_7 lab=VSS}
C {./dffnrnq_1.sym} 0 42450 0 0 {name=Xn_2197}
N -92 42420 -112 42420 {lab=u_cas_diff_out_diff1_b7}
C {./lab_pin.sym} -112 42420 0 0 {name=l2256_0 lab=u_cas_diff_out_diff1_b7}
N -92 42440 -112 42440 {lab=net19}
C {./lab_pin.sym} -112 42440 0 0 {name=l2256_1 lab=net19}
N -92 42460 -112 42460 {lab=net16}
C {./lab_pin.sym} -112 42460 0 0 {name=l2256_2 lab=net16}
N -92 42480 -112 42480 {lab=u_cas_diff_u_diff2_in_min1_b7}
C {./lab_pin.sym} -112 42480 0 0 {name=l2256_3 lab=u_cas_diff_u_diff2_in_min1_b7}
N 92 42420 112 42420 {lab=VDD}
C {./lab_pin.sym} 112 42420 0 1 {name=l2256_4 lab=VDD}
N 92 42440 112 42440 {lab=VDD}
C {./lab_pin.sym} 112 42440 0 1 {name=l2256_5 lab=VDD}
N 92 42460 112 42460 {lab=VSS}
C {./lab_pin.sym} 112 42460 0 1 {name=l2256_6 lab=VSS}
N 92 42480 112 42480 {lab=VSS}
C {./lab_pin.sym} 112 42480 0 1 {name=l2256_7 lab=VSS}
C {./dffnrnq_1.sym} 405 42450 0 0 {name=Xn_2198}
N 313 42420 293 42420 {lab=u_cas_diff_out_diff1_b8}
C {./lab_pin.sym} 293 42420 0 0 {name=l2257_0 lab=u_cas_diff_out_diff1_b8}
N 313 42440 293 42440 {lab=net19}
C {./lab_pin.sym} 293 42440 0 0 {name=l2257_1 lab=net19}
N 313 42460 293 42460 {lab=net16}
C {./lab_pin.sym} 293 42460 0 0 {name=l2257_2 lab=net16}
N 313 42480 293 42480 {lab=u_cas_diff_u_diff2_in_min1_b8}
C {./lab_pin.sym} 293 42480 0 0 {name=l2257_3 lab=u_cas_diff_u_diff2_in_min1_b8}
N 497 42420 517 42420 {lab=VDD}
C {./lab_pin.sym} 517 42420 0 1 {name=l2257_4 lab=VDD}
N 497 42440 517 42440 {lab=VDD}
C {./lab_pin.sym} 517 42440 0 1 {name=l2257_5 lab=VDD}
N 497 42460 517 42460 {lab=VSS}
C {./lab_pin.sym} 517 42460 0 1 {name=l2257_6 lab=VSS}
N 497 42480 517 42480 {lab=VSS}
C {./lab_pin.sym} 517 42480 0 1 {name=l2257_7 lab=VSS}
C {./dffnrnq_1.sym} 810 42450 0 0 {name=Xn_2199}
N 718 42420 698 42420 {lab=u_cas_diff_out_diff1_b9}
C {./lab_pin.sym} 698 42420 0 0 {name=l2258_0 lab=u_cas_diff_out_diff1_b9}
N 718 42440 698 42440 {lab=net19}
C {./lab_pin.sym} 698 42440 0 0 {name=l2258_1 lab=net19}
N 718 42460 698 42460 {lab=net16}
C {./lab_pin.sym} 698 42460 0 0 {name=l2258_2 lab=net16}
N 718 42480 698 42480 {lab=u_cas_diff_u_diff2_in_min1_b9}
C {./lab_pin.sym} 698 42480 0 0 {name=l2258_3 lab=u_cas_diff_u_diff2_in_min1_b9}
N 902 42420 922 42420 {lab=VDD}
C {./lab_pin.sym} 922 42420 0 1 {name=l2258_4 lab=VDD}
N 902 42440 922 42440 {lab=VDD}
C {./lab_pin.sym} 922 42440 0 1 {name=l2258_5 lab=VDD}
N 902 42460 922 42460 {lab=VSS}
C {./lab_pin.sym} 922 42460 0 1 {name=l2258_6 lab=VSS}
N 902 42480 922 42480 {lab=VSS}
C {./lab_pin.sym} 922 42480 0 1 {name=l2258_7 lab=VSS}
C {./dffnrnq_1.sym} 1215 42450 0 0 {name=Xn_2200}
N 1123 42420 1103 42420 {lab=u_cas_diff_out_diff1_b10}
C {./lab_pin.sym} 1103 42420 0 0 {name=l2259_0 lab=u_cas_diff_out_diff1_b10}
N 1123 42440 1103 42440 {lab=net19}
C {./lab_pin.sym} 1103 42440 0 0 {name=l2259_1 lab=net19}
N 1123 42460 1103 42460 {lab=net16}
C {./lab_pin.sym} 1103 42460 0 0 {name=l2259_2 lab=net16}
N 1123 42480 1103 42480 {lab=u_cas_diff_u_diff2_in_min1_b10}
C {./lab_pin.sym} 1103 42480 0 0 {name=l2259_3 lab=u_cas_diff_u_diff2_in_min1_b10}
N 1307 42420 1327 42420 {lab=VDD}
C {./lab_pin.sym} 1327 42420 0 1 {name=l2259_4 lab=VDD}
N 1307 42440 1327 42440 {lab=VDD}
C {./lab_pin.sym} 1327 42440 0 1 {name=l2259_5 lab=VDD}
N 1307 42460 1327 42460 {lab=VSS}
C {./lab_pin.sym} 1327 42460 0 1 {name=l2259_6 lab=VSS}
N 1307 42480 1327 42480 {lab=VSS}
C {./lab_pin.sym} 1327 42480 0 1 {name=l2259_7 lab=VSS}
C {./dffnrnq_1.sym} 1620 42450 0 0 {name=Xn_2201}
N 1528 42420 1508 42420 {lab=u_cas_diff_out_diff1_b11}
C {./lab_pin.sym} 1508 42420 0 0 {name=l2260_0 lab=u_cas_diff_out_diff1_b11}
N 1528 42440 1508 42440 {lab=net19}
C {./lab_pin.sym} 1508 42440 0 0 {name=l2260_1 lab=net19}
N 1528 42460 1508 42460 {lab=net16}
C {./lab_pin.sym} 1508 42460 0 0 {name=l2260_2 lab=net16}
N 1528 42480 1508 42480 {lab=u_cas_diff_u_diff2_in_min1_b11}
C {./lab_pin.sym} 1508 42480 0 0 {name=l2260_3 lab=u_cas_diff_u_diff2_in_min1_b11}
N 1712 42420 1732 42420 {lab=VDD}
C {./lab_pin.sym} 1732 42420 0 1 {name=l2260_4 lab=VDD}
N 1712 42440 1732 42440 {lab=VDD}
C {./lab_pin.sym} 1732 42440 0 1 {name=l2260_5 lab=VDD}
N 1712 42460 1732 42460 {lab=VSS}
C {./lab_pin.sym} 1732 42460 0 1 {name=l2260_6 lab=VSS}
N 1712 42480 1732 42480 {lab=VSS}
C {./lab_pin.sym} 1732 42480 0 1 {name=l2260_7 lab=VSS}
C {./dffnrnq_1.sym} 2025 42450 0 0 {name=Xn_2202}
N 1933 42420 1913 42420 {lab=u_cas_diff_out_diff1_b12}
C {./lab_pin.sym} 1913 42420 0 0 {name=l2261_0 lab=u_cas_diff_out_diff1_b12}
N 1933 42440 1913 42440 {lab=net19}
C {./lab_pin.sym} 1913 42440 0 0 {name=l2261_1 lab=net19}
N 1933 42460 1913 42460 {lab=net16}
C {./lab_pin.sym} 1913 42460 0 0 {name=l2261_2 lab=net16}
N 1933 42480 1913 42480 {lab=u_cas_diff_u_diff2_in_min1_b12}
C {./lab_pin.sym} 1913 42480 0 0 {name=l2261_3 lab=u_cas_diff_u_diff2_in_min1_b12}
N 2117 42420 2137 42420 {lab=VDD}
C {./lab_pin.sym} 2137 42420 0 1 {name=l2261_4 lab=VDD}
N 2117 42440 2137 42440 {lab=VDD}
C {./lab_pin.sym} 2137 42440 0 1 {name=l2261_5 lab=VDD}
N 2117 42460 2137 42460 {lab=VSS}
C {./lab_pin.sym} 2137 42460 0 1 {name=l2261_6 lab=VSS}
N 2117 42480 2137 42480 {lab=VSS}
C {./lab_pin.sym} 2137 42480 0 1 {name=l2261_7 lab=VSS}
C {./dffnrnq_1.sym} 2430 42450 0 0 {name=Xn_2203}
N 2338 42420 2318 42420 {lab=u_cas_diff_out_diff1_b13}
C {./lab_pin.sym} 2318 42420 0 0 {name=l2262_0 lab=u_cas_diff_out_diff1_b13}
N 2338 42440 2318 42440 {lab=net19}
C {./lab_pin.sym} 2318 42440 0 0 {name=l2262_1 lab=net19}
N 2338 42460 2318 42460 {lab=net16}
C {./lab_pin.sym} 2318 42460 0 0 {name=l2262_2 lab=net16}
N 2338 42480 2318 42480 {lab=u_cas_diff_u_diff2_in_min1_b13}
C {./lab_pin.sym} 2318 42480 0 0 {name=l2262_3 lab=u_cas_diff_u_diff2_in_min1_b13}
N 2522 42420 2542 42420 {lab=VDD}
C {./lab_pin.sym} 2542 42420 0 1 {name=l2262_4 lab=VDD}
N 2522 42440 2542 42440 {lab=VDD}
C {./lab_pin.sym} 2542 42440 0 1 {name=l2262_5 lab=VDD}
N 2522 42460 2542 42460 {lab=VSS}
C {./lab_pin.sym} 2542 42460 0 1 {name=l2262_6 lab=VSS}
N 2522 42480 2542 42480 {lab=VSS}
C {./lab_pin.sym} 2542 42480 0 1 {name=l2262_7 lab=VSS}
C {./dffnrnq_1.sym} 2835 42450 0 0 {name=Xn_2204}
N 2743 42420 2723 42420 {lab=u_cas_diff_out_diff1_b14}
C {./lab_pin.sym} 2723 42420 0 0 {name=l2263_0 lab=u_cas_diff_out_diff1_b14}
N 2743 42440 2723 42440 {lab=net19}
C {./lab_pin.sym} 2723 42440 0 0 {name=l2263_1 lab=net19}
N 2743 42460 2723 42460 {lab=net16}
C {./lab_pin.sym} 2723 42460 0 0 {name=l2263_2 lab=net16}
N 2743 42480 2723 42480 {lab=u_cas_diff_u_diff2_in_min1_b14}
C {./lab_pin.sym} 2723 42480 0 0 {name=l2263_3 lab=u_cas_diff_u_diff2_in_min1_b14}
N 2927 42420 2947 42420 {lab=VDD}
C {./lab_pin.sym} 2947 42420 0 1 {name=l2263_4 lab=VDD}
N 2927 42440 2947 42440 {lab=VDD}
C {./lab_pin.sym} 2947 42440 0 1 {name=l2263_5 lab=VDD}
N 2927 42460 2947 42460 {lab=VSS}
C {./lab_pin.sym} 2947 42460 0 1 {name=l2263_6 lab=VSS}
N 2927 42480 2947 42480 {lab=VSS}
C {./lab_pin.sym} 2947 42480 0 1 {name=l2263_7 lab=VSS}
C {./dffnrnq_1.sym} 3240 42450 0 0 {name=Xn_2205}
N 3148 42420 3128 42420 {lab=u_cas_diff_out_diff1_b15}
C {./lab_pin.sym} 3128 42420 0 0 {name=l2264_0 lab=u_cas_diff_out_diff1_b15}
N 3148 42440 3128 42440 {lab=net19}
C {./lab_pin.sym} 3128 42440 0 0 {name=l2264_1 lab=net19}
N 3148 42460 3128 42460 {lab=net16}
C {./lab_pin.sym} 3128 42460 0 0 {name=l2264_2 lab=net16}
N 3148 42480 3128 42480 {lab=u_cas_diff_u_diff2_in_min1_b15}
C {./lab_pin.sym} 3128 42480 0 0 {name=l2264_3 lab=u_cas_diff_u_diff2_in_min1_b15}
N 3332 42420 3352 42420 {lab=VDD}
C {./lab_pin.sym} 3352 42420 0 1 {name=l2264_4 lab=VDD}
N 3332 42440 3352 42440 {lab=VDD}
C {./lab_pin.sym} 3352 42440 0 1 {name=l2264_5 lab=VDD}
N 3332 42460 3352 42460 {lab=VSS}
C {./lab_pin.sym} 3352 42460 0 1 {name=l2264_6 lab=VSS}
N 3332 42480 3352 42480 {lab=VSS}
C {./lab_pin.sym} 3352 42480 0 1 {name=l2264_7 lab=VSS}
C {./dffnrnq_1.sym} 3645 42450 0 0 {name=Xn_2206}
N 3553 42420 3533 42420 {lab=u_cas_diff_out_diff1_b16}
C {./lab_pin.sym} 3533 42420 0 0 {name=l2265_0 lab=u_cas_diff_out_diff1_b16}
N 3553 42440 3533 42440 {lab=net19}
C {./lab_pin.sym} 3533 42440 0 0 {name=l2265_1 lab=net19}
N 3553 42460 3533 42460 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 3533 42460 0 0 {name=l2265_2 lab=u_clock_div_counter_b7}
N 3553 42480 3533 42480 {lab=u_cas_diff_u_diff2_in_min1_b16}
C {./lab_pin.sym} 3533 42480 0 0 {name=l2265_3 lab=u_cas_diff_u_diff2_in_min1_b16}
N 3737 42420 3757 42420 {lab=VDD}
C {./lab_pin.sym} 3757 42420 0 1 {name=l2265_4 lab=VDD}
N 3737 42440 3757 42440 {lab=VDD}
C {./lab_pin.sym} 3757 42440 0 1 {name=l2265_5 lab=VDD}
N 3737 42460 3757 42460 {lab=VSS}
C {./lab_pin.sym} 3757 42460 0 1 {name=l2265_6 lab=VSS}
N 3737 42480 3757 42480 {lab=VSS}
C {./lab_pin.sym} 3757 42480 0 1 {name=l2265_7 lab=VSS}
C {./dffnrnq_1.sym} 4050 42450 0 0 {name=Xn_2207}
N 3958 42420 3938 42420 {lab=u_cas_diff_out_diff1_b17}
C {./lab_pin.sym} 3938 42420 0 0 {name=l2266_0 lab=u_cas_diff_out_diff1_b17}
N 3958 42440 3938 42440 {lab=net19}
C {./lab_pin.sym} 3938 42440 0 0 {name=l2266_1 lab=net19}
N 3958 42460 3938 42460 {lab=net16}
C {./lab_pin.sym} 3938 42460 0 0 {name=l2266_2 lab=net16}
N 3958 42480 3938 42480 {lab=u_cas_diff_u_diff2_in_min1_b17}
C {./lab_pin.sym} 3938 42480 0 0 {name=l2266_3 lab=u_cas_diff_u_diff2_in_min1_b17}
N 4142 42420 4162 42420 {lab=VDD}
C {./lab_pin.sym} 4162 42420 0 1 {name=l2266_4 lab=VDD}
N 4142 42440 4162 42440 {lab=VDD}
C {./lab_pin.sym} 4162 42440 0 1 {name=l2266_5 lab=VDD}
N 4142 42460 4162 42460 {lab=VSS}
C {./lab_pin.sym} 4162 42460 0 1 {name=l2266_6 lab=VSS}
N 4142 42480 4162 42480 {lab=VSS}
C {./lab_pin.sym} 4162 42480 0 1 {name=l2266_7 lab=VSS}
C {./dffnrnq_1.sym} 4455 42450 0 0 {name=Xn_2208}
N 4363 42420 4343 42420 {lab=u_cas_diff_out_diff1_b18}
C {./lab_pin.sym} 4343 42420 0 0 {name=l2267_0 lab=u_cas_diff_out_diff1_b18}
N 4363 42440 4343 42440 {lab=net19}
C {./lab_pin.sym} 4343 42440 0 0 {name=l2267_1 lab=net19}
N 4363 42460 4343 42460 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 4343 42460 0 0 {name=l2267_2 lab=u_clock_div_counter_b7}
N 4363 42480 4343 42480 {lab=u_cas_diff_u_diff2_in_min1_b18}
C {./lab_pin.sym} 4343 42480 0 0 {name=l2267_3 lab=u_cas_diff_u_diff2_in_min1_b18}
N 4547 42420 4567 42420 {lab=VDD}
C {./lab_pin.sym} 4567 42420 0 1 {name=l2267_4 lab=VDD}
N 4547 42440 4567 42440 {lab=VDD}
C {./lab_pin.sym} 4567 42440 0 1 {name=l2267_5 lab=VDD}
N 4547 42460 4567 42460 {lab=VSS}
C {./lab_pin.sym} 4567 42460 0 1 {name=l2267_6 lab=VSS}
N 4547 42480 4567 42480 {lab=VSS}
C {./lab_pin.sym} 4567 42480 0 1 {name=l2267_7 lab=VSS}
C {./dffnrnq_1.sym} 0 42675 0 0 {name=Xn_2209}
N -92 42645 -112 42645 {lab=u_cas_diff_out_diff1_b19}
C {./lab_pin.sym} -112 42645 0 0 {name=l2268_0 lab=u_cas_diff_out_diff1_b19}
N -92 42665 -112 42665 {lab=net19}
C {./lab_pin.sym} -112 42665 0 0 {name=l2268_1 lab=net19}
N -92 42685 -112 42685 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} -112 42685 0 0 {name=l2268_2 lab=u_clock_div_counter_b7}
N -92 42705 -112 42705 {lab=u_cas_diff_u_diff2_in_min1_b19}
C {./lab_pin.sym} -112 42705 0 0 {name=l2268_3 lab=u_cas_diff_u_diff2_in_min1_b19}
N 92 42645 112 42645 {lab=VDD}
C {./lab_pin.sym} 112 42645 0 1 {name=l2268_4 lab=VDD}
N 92 42665 112 42665 {lab=VDD}
C {./lab_pin.sym} 112 42665 0 1 {name=l2268_5 lab=VDD}
N 92 42685 112 42685 {lab=VSS}
C {./lab_pin.sym} 112 42685 0 1 {name=l2268_6 lab=VSS}
N 92 42705 112 42705 {lab=VSS}
C {./lab_pin.sym} 112 42705 0 1 {name=l2268_7 lab=VSS}
C {./dffnrnq_1.sym} 405 42675 0 0 {name=Xn_2210}
N 313 42645 293 42645 {lab=u_cas_diff_out_diff1_b20}
C {./lab_pin.sym} 293 42645 0 0 {name=l2269_0 lab=u_cas_diff_out_diff1_b20}
N 313 42665 293 42665 {lab=net19}
C {./lab_pin.sym} 293 42665 0 0 {name=l2269_1 lab=net19}
N 313 42685 293 42685 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 293 42685 0 0 {name=l2269_2 lab=u_clock_div_counter_b7}
N 313 42705 293 42705 {lab=u_cas_diff_u_diff2_in_min1_b20}
C {./lab_pin.sym} 293 42705 0 0 {name=l2269_3 lab=u_cas_diff_u_diff2_in_min1_b20}
N 497 42645 517 42645 {lab=VDD}
C {./lab_pin.sym} 517 42645 0 1 {name=l2269_4 lab=VDD}
N 497 42665 517 42665 {lab=VDD}
C {./lab_pin.sym} 517 42665 0 1 {name=l2269_5 lab=VDD}
N 497 42685 517 42685 {lab=VSS}
C {./lab_pin.sym} 517 42685 0 1 {name=l2269_6 lab=VSS}
N 497 42705 517 42705 {lab=VSS}
C {./lab_pin.sym} 517 42705 0 1 {name=l2269_7 lab=VSS}
C {./dffnrnq_1.sym} 810 42675 0 0 {name=Xn_2211}
N 718 42645 698 42645 {lab=u_cas_diff_out_diff1_b21}
C {./lab_pin.sym} 698 42645 0 0 {name=l2270_0 lab=u_cas_diff_out_diff1_b21}
N 718 42665 698 42665 {lab=net19}
C {./lab_pin.sym} 698 42665 0 0 {name=l2270_1 lab=net19}
N 718 42685 698 42685 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 698 42685 0 0 {name=l2270_2 lab=u_clock_div_counter_b7}
N 718 42705 698 42705 {lab=u_cas_diff_u_diff2_in_min1_b21}
C {./lab_pin.sym} 698 42705 0 0 {name=l2270_3 lab=u_cas_diff_u_diff2_in_min1_b21}
N 902 42645 922 42645 {lab=VDD}
C {./lab_pin.sym} 922 42645 0 1 {name=l2270_4 lab=VDD}
N 902 42665 922 42665 {lab=VDD}
C {./lab_pin.sym} 922 42665 0 1 {name=l2270_5 lab=VDD}
N 902 42685 922 42685 {lab=VSS}
C {./lab_pin.sym} 922 42685 0 1 {name=l2270_6 lab=VSS}
N 902 42705 922 42705 {lab=VSS}
C {./lab_pin.sym} 922 42705 0 1 {name=l2270_7 lab=VSS}
C {./dffnrnq_1.sym} 1215 42675 0 0 {name=Xn_2212}
N 1123 42645 1103 42645 {lab=u_cas_diff_out_diff1_b22}
C {./lab_pin.sym} 1103 42645 0 0 {name=l2271_0 lab=u_cas_diff_out_diff1_b22}
N 1123 42665 1103 42665 {lab=net19}
C {./lab_pin.sym} 1103 42665 0 0 {name=l2271_1 lab=net19}
N 1123 42685 1103 42685 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 1103 42685 0 0 {name=l2271_2 lab=u_clock_div_counter_b7}
N 1123 42705 1103 42705 {lab=u_cas_diff_u_diff2_in_min1_b22}
C {./lab_pin.sym} 1103 42705 0 0 {name=l2271_3 lab=u_cas_diff_u_diff2_in_min1_b22}
N 1307 42645 1327 42645 {lab=VDD}
C {./lab_pin.sym} 1327 42645 0 1 {name=l2271_4 lab=VDD}
N 1307 42665 1327 42665 {lab=VDD}
C {./lab_pin.sym} 1327 42665 0 1 {name=l2271_5 lab=VDD}
N 1307 42685 1327 42685 {lab=VSS}
C {./lab_pin.sym} 1327 42685 0 1 {name=l2271_6 lab=VSS}
N 1307 42705 1327 42705 {lab=VSS}
C {./lab_pin.sym} 1327 42705 0 1 {name=l2271_7 lab=VSS}
C {./dffnrnq_1.sym} 1620 42675 0 0 {name=Xn_2213}
N 1528 42645 1508 42645 {lab=u_cas_diff_out_diff1_b23}
C {./lab_pin.sym} 1508 42645 0 0 {name=l2272_0 lab=u_cas_diff_out_diff1_b23}
N 1528 42665 1508 42665 {lab=net20}
C {./lab_pin.sym} 1508 42665 0 0 {name=l2272_1 lab=net20}
N 1528 42685 1508 42685 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 1508 42685 0 0 {name=l2272_2 lab=u_clock_div_counter_b7}
N 1528 42705 1508 42705 {lab=u_cas_diff_u_diff2_in_min1_b23}
C {./lab_pin.sym} 1508 42705 0 0 {name=l2272_3 lab=u_cas_diff_u_diff2_in_min1_b23}
N 1712 42645 1732 42645 {lab=VDD}
C {./lab_pin.sym} 1732 42645 0 1 {name=l2272_4 lab=VDD}
N 1712 42665 1732 42665 {lab=VDD}
C {./lab_pin.sym} 1732 42665 0 1 {name=l2272_5 lab=VDD}
N 1712 42685 1732 42685 {lab=VSS}
C {./lab_pin.sym} 1732 42685 0 1 {name=l2272_6 lab=VSS}
N 1712 42705 1732 42705 {lab=VSS}
C {./lab_pin.sym} 1732 42705 0 1 {name=l2272_7 lab=VSS}
C {./dffnrnq_1.sym} 2025 42675 0 0 {name=Xn_2214}
N 1933 42645 1913 42645 {lab=u_cas_diff_out_diff1_b24}
C {./lab_pin.sym} 1913 42645 0 0 {name=l2273_0 lab=u_cas_diff_out_diff1_b24}
N 1933 42665 1913 42665 {lab=net20}
C {./lab_pin.sym} 1913 42665 0 0 {name=l2273_1 lab=net20}
N 1933 42685 1913 42685 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 1913 42685 0 0 {name=l2273_2 lab=u_clock_div_counter_b7}
N 1933 42705 1913 42705 {lab=u_cas_diff_u_diff2_in_min1_b24}
C {./lab_pin.sym} 1913 42705 0 0 {name=l2273_3 lab=u_cas_diff_u_diff2_in_min1_b24}
N 2117 42645 2137 42645 {lab=VDD}
C {./lab_pin.sym} 2137 42645 0 1 {name=l2273_4 lab=VDD}
N 2117 42665 2137 42665 {lab=VDD}
C {./lab_pin.sym} 2137 42665 0 1 {name=l2273_5 lab=VDD}
N 2117 42685 2137 42685 {lab=VSS}
C {./lab_pin.sym} 2137 42685 0 1 {name=l2273_6 lab=VSS}
N 2117 42705 2137 42705 {lab=VSS}
C {./lab_pin.sym} 2137 42705 0 1 {name=l2273_7 lab=VSS}
C {./dffnrnq_1.sym} 2430 42675 0 0 {name=Xn_2215}
N 2338 42645 2318 42645 {lab=n_0025}
C {./lab_pin.sym} 2318 42645 0 0 {name=l2274_0 lab=n_0025}
N 2338 42665 2318 42665 {lab=net21}
C {./lab_pin.sym} 2318 42665 0 0 {name=l2274_1 lab=net21}
N 2338 42685 2318 42685 {lab=net16}
C {./lab_pin.sym} 2318 42685 0 0 {name=l2274_2 lab=net16}
N 2338 42705 2318 42705 {lab=u_cas_diff_out_diff2_b0}
C {./lab_pin.sym} 2318 42705 0 0 {name=l2274_3 lab=u_cas_diff_out_diff2_b0}
N 2522 42645 2542 42645 {lab=VDD}
C {./lab_pin.sym} 2542 42645 0 1 {name=l2274_4 lab=VDD}
N 2522 42665 2542 42665 {lab=VDD}
C {./lab_pin.sym} 2542 42665 0 1 {name=l2274_5 lab=VDD}
N 2522 42685 2542 42685 {lab=VSS}
C {./lab_pin.sym} 2542 42685 0 1 {name=l2274_6 lab=VSS}
N 2522 42705 2542 42705 {lab=VSS}
C {./lab_pin.sym} 2542 42705 0 1 {name=l2274_7 lab=VSS}
C {./dffnrnq_1.sym} 2835 42675 0 0 {name=Xn_2216}
N 2743 42645 2723 42645 {lab=n_0036}
C {./lab_pin.sym} 2723 42645 0 0 {name=l2275_0 lab=n_0036}
N 2743 42665 2723 42665 {lab=net21}
C {./lab_pin.sym} 2723 42665 0 0 {name=l2275_1 lab=net21}
N 2743 42685 2723 42685 {lab=net16}
C {./lab_pin.sym} 2723 42685 0 0 {name=l2275_2 lab=net16}
N 2743 42705 2723 42705 {lab=u_cas_diff_out_diff2_b1}
C {./lab_pin.sym} 2723 42705 0 0 {name=l2275_3 lab=u_cas_diff_out_diff2_b1}
N 2927 42645 2947 42645 {lab=VDD}
C {./lab_pin.sym} 2947 42645 0 1 {name=l2275_4 lab=VDD}
N 2927 42665 2947 42665 {lab=VDD}
C {./lab_pin.sym} 2947 42665 0 1 {name=l2275_5 lab=VDD}
N 2927 42685 2947 42685 {lab=VSS}
C {./lab_pin.sym} 2947 42685 0 1 {name=l2275_6 lab=VSS}
N 2927 42705 2947 42705 {lab=VSS}
C {./lab_pin.sym} 2947 42705 0 1 {name=l2275_7 lab=VSS}
C {./dffnrnq_1.sym} 3240 42675 0 0 {name=Xn_2217}
N 3148 42645 3128 42645 {lab=n_0042}
C {./lab_pin.sym} 3128 42645 0 0 {name=l2276_0 lab=n_0042}
N 3148 42665 3128 42665 {lab=net21}
C {./lab_pin.sym} 3128 42665 0 0 {name=l2276_1 lab=net21}
N 3148 42685 3128 42685 {lab=net16}
C {./lab_pin.sym} 3128 42685 0 0 {name=l2276_2 lab=net16}
N 3148 42705 3128 42705 {lab=u_cas_diff_out_diff2_b2}
C {./lab_pin.sym} 3128 42705 0 0 {name=l2276_3 lab=u_cas_diff_out_diff2_b2}
N 3332 42645 3352 42645 {lab=VDD}
C {./lab_pin.sym} 3352 42645 0 1 {name=l2276_4 lab=VDD}
N 3332 42665 3352 42665 {lab=VDD}
C {./lab_pin.sym} 3352 42665 0 1 {name=l2276_5 lab=VDD}
N 3332 42685 3352 42685 {lab=VSS}
C {./lab_pin.sym} 3352 42685 0 1 {name=l2276_6 lab=VSS}
N 3332 42705 3352 42705 {lab=VSS}
C {./lab_pin.sym} 3352 42705 0 1 {name=l2276_7 lab=VSS}
C {./dffnrnq_1.sym} 3645 42675 0 0 {name=Xn_2218}
N 3553 42645 3533 42645 {lab=n_0043}
C {./lab_pin.sym} 3533 42645 0 0 {name=l2277_0 lab=n_0043}
N 3553 42665 3533 42665 {lab=net21}
C {./lab_pin.sym} 3533 42665 0 0 {name=l2277_1 lab=net21}
N 3553 42685 3533 42685 {lab=net16}
C {./lab_pin.sym} 3533 42685 0 0 {name=l2277_2 lab=net16}
N 3553 42705 3533 42705 {lab=u_cas_diff_out_diff2_b3}
C {./lab_pin.sym} 3533 42705 0 0 {name=l2277_3 lab=u_cas_diff_out_diff2_b3}
N 3737 42645 3757 42645 {lab=VDD}
C {./lab_pin.sym} 3757 42645 0 1 {name=l2277_4 lab=VDD}
N 3737 42665 3757 42665 {lab=VDD}
C {./lab_pin.sym} 3757 42665 0 1 {name=l2277_5 lab=VDD}
N 3737 42685 3757 42685 {lab=VSS}
C {./lab_pin.sym} 3757 42685 0 1 {name=l2277_6 lab=VSS}
N 3737 42705 3757 42705 {lab=VSS}
C {./lab_pin.sym} 3757 42705 0 1 {name=l2277_7 lab=VSS}
C {./dffnrnq_1.sym} 4050 42675 0 0 {name=Xn_2219}
N 3958 42645 3938 42645 {lab=n_0044}
C {./lab_pin.sym} 3938 42645 0 0 {name=l2278_0 lab=n_0044}
N 3958 42665 3938 42665 {lab=net21}
C {./lab_pin.sym} 3938 42665 0 0 {name=l2278_1 lab=net21}
N 3958 42685 3938 42685 {lab=net16}
C {./lab_pin.sym} 3938 42685 0 0 {name=l2278_2 lab=net16}
N 3958 42705 3938 42705 {lab=u_cas_diff_out_diff2_b4}
C {./lab_pin.sym} 3938 42705 0 0 {name=l2278_3 lab=u_cas_diff_out_diff2_b4}
N 4142 42645 4162 42645 {lab=VDD}
C {./lab_pin.sym} 4162 42645 0 1 {name=l2278_4 lab=VDD}
N 4142 42665 4162 42665 {lab=VDD}
C {./lab_pin.sym} 4162 42665 0 1 {name=l2278_5 lab=VDD}
N 4142 42685 4162 42685 {lab=VSS}
C {./lab_pin.sym} 4162 42685 0 1 {name=l2278_6 lab=VSS}
N 4142 42705 4162 42705 {lab=VSS}
C {./lab_pin.sym} 4162 42705 0 1 {name=l2278_7 lab=VSS}
C {./dffnrnq_1.sym} 4455 42675 0 0 {name=Xn_2220}
N 4363 42645 4343 42645 {lab=n_0045}
C {./lab_pin.sym} 4343 42645 0 0 {name=l2279_0 lab=n_0045}
N 4363 42665 4343 42665 {lab=net2}
C {./lab_pin.sym} 4343 42665 0 0 {name=l2279_1 lab=net2}
N 4363 42685 4343 42685 {lab=net16}
C {./lab_pin.sym} 4343 42685 0 0 {name=l2279_2 lab=net16}
N 4363 42705 4343 42705 {lab=u_cas_diff_out_diff2_b5}
C {./lab_pin.sym} 4343 42705 0 0 {name=l2279_3 lab=u_cas_diff_out_diff2_b5}
N 4547 42645 4567 42645 {lab=VDD}
C {./lab_pin.sym} 4567 42645 0 1 {name=l2279_4 lab=VDD}
N 4547 42665 4567 42665 {lab=VDD}
C {./lab_pin.sym} 4567 42665 0 1 {name=l2279_5 lab=VDD}
N 4547 42685 4567 42685 {lab=VSS}
C {./lab_pin.sym} 4567 42685 0 1 {name=l2279_6 lab=VSS}
N 4547 42705 4567 42705 {lab=VSS}
C {./lab_pin.sym} 4567 42705 0 1 {name=l2279_7 lab=VSS}
C {./dffnrnq_1.sym} 0 42900 0 0 {name=Xn_2221}
N -92 42870 -112 42870 {lab=n_0046}
C {./lab_pin.sym} -112 42870 0 0 {name=l2280_0 lab=n_0046}
N -92 42890 -112 42890 {lab=net20}
C {./lab_pin.sym} -112 42890 0 0 {name=l2280_1 lab=net20}
N -92 42910 -112 42910 {lab=net15}
C {./lab_pin.sym} -112 42910 0 0 {name=l2280_2 lab=net15}
N -92 42930 -112 42930 {lab=u_cas_diff_out_diff2_b6}
C {./lab_pin.sym} -112 42930 0 0 {name=l2280_3 lab=u_cas_diff_out_diff2_b6}
N 92 42870 112 42870 {lab=VDD}
C {./lab_pin.sym} 112 42870 0 1 {name=l2280_4 lab=VDD}
N 92 42890 112 42890 {lab=VDD}
C {./lab_pin.sym} 112 42890 0 1 {name=l2280_5 lab=VDD}
N 92 42910 112 42910 {lab=VSS}
C {./lab_pin.sym} 112 42910 0 1 {name=l2280_6 lab=VSS}
N 92 42930 112 42930 {lab=VSS}
C {./lab_pin.sym} 112 42930 0 1 {name=l2280_7 lab=VSS}
C {./dffnrnq_1.sym} 405 42900 0 0 {name=Xn_2222}
N 313 42870 293 42870 {lab=n_0047}
C {./lab_pin.sym} 293 42870 0 0 {name=l2281_0 lab=n_0047}
N 313 42890 293 42890 {lab=net20}
C {./lab_pin.sym} 293 42890 0 0 {name=l2281_1 lab=net20}
N 313 42910 293 42910 {lab=net15}
C {./lab_pin.sym} 293 42910 0 0 {name=l2281_2 lab=net15}
N 313 42930 293 42930 {lab=u_cas_diff_out_diff2_b7}
C {./lab_pin.sym} 293 42930 0 0 {name=l2281_3 lab=u_cas_diff_out_diff2_b7}
N 497 42870 517 42870 {lab=VDD}
C {./lab_pin.sym} 517 42870 0 1 {name=l2281_4 lab=VDD}
N 497 42890 517 42890 {lab=VDD}
C {./lab_pin.sym} 517 42890 0 1 {name=l2281_5 lab=VDD}
N 497 42910 517 42910 {lab=VSS}
C {./lab_pin.sym} 517 42910 0 1 {name=l2281_6 lab=VSS}
N 497 42930 517 42930 {lab=VSS}
C {./lab_pin.sym} 517 42930 0 1 {name=l2281_7 lab=VSS}
C {./dffnrnq_1.sym} 810 42900 0 0 {name=Xn_2223}
N 718 42870 698 42870 {lab=n_0048}
C {./lab_pin.sym} 698 42870 0 0 {name=l2282_0 lab=n_0048}
N 718 42890 698 42890 {lab=net20}
C {./lab_pin.sym} 698 42890 0 0 {name=l2282_1 lab=net20}
N 718 42910 698 42910 {lab=net15}
C {./lab_pin.sym} 698 42910 0 0 {name=l2282_2 lab=net15}
N 718 42930 698 42930 {lab=u_cas_diff_out_diff2_b8}
C {./lab_pin.sym} 698 42930 0 0 {name=l2282_3 lab=u_cas_diff_out_diff2_b8}
N 902 42870 922 42870 {lab=VDD}
C {./lab_pin.sym} 922 42870 0 1 {name=l2282_4 lab=VDD}
N 902 42890 922 42890 {lab=VDD}
C {./lab_pin.sym} 922 42890 0 1 {name=l2282_5 lab=VDD}
N 902 42910 922 42910 {lab=VSS}
C {./lab_pin.sym} 922 42910 0 1 {name=l2282_6 lab=VSS}
N 902 42930 922 42930 {lab=VSS}
C {./lab_pin.sym} 922 42930 0 1 {name=l2282_7 lab=VSS}
C {./dffnrnq_1.sym} 1215 42900 0 0 {name=Xn_2224}
N 1123 42870 1103 42870 {lab=n_0049}
C {./lab_pin.sym} 1103 42870 0 0 {name=l2283_0 lab=n_0049}
N 1123 42890 1103 42890 {lab=net20}
C {./lab_pin.sym} 1103 42890 0 0 {name=l2283_1 lab=net20}
N 1123 42910 1103 42910 {lab=net15}
C {./lab_pin.sym} 1103 42910 0 0 {name=l2283_2 lab=net15}
N 1123 42930 1103 42930 {lab=u_cas_diff_out_diff2_b9}
C {./lab_pin.sym} 1103 42930 0 0 {name=l2283_3 lab=u_cas_diff_out_diff2_b9}
N 1307 42870 1327 42870 {lab=VDD}
C {./lab_pin.sym} 1327 42870 0 1 {name=l2283_4 lab=VDD}
N 1307 42890 1327 42890 {lab=VDD}
C {./lab_pin.sym} 1327 42890 0 1 {name=l2283_5 lab=VDD}
N 1307 42910 1327 42910 {lab=VSS}
C {./lab_pin.sym} 1327 42910 0 1 {name=l2283_6 lab=VSS}
N 1307 42930 1327 42930 {lab=VSS}
C {./lab_pin.sym} 1327 42930 0 1 {name=l2283_7 lab=VSS}
C {./dffnrnq_1.sym} 1620 42900 0 0 {name=Xn_2225}
N 1528 42870 1508 42870 {lab=n_0026}
C {./lab_pin.sym} 1508 42870 0 0 {name=l2284_0 lab=n_0026}
N 1528 42890 1508 42890 {lab=net20}
C {./lab_pin.sym} 1508 42890 0 0 {name=l2284_1 lab=net20}
N 1528 42910 1508 42910 {lab=net15}
C {./lab_pin.sym} 1508 42910 0 0 {name=l2284_2 lab=net15}
N 1528 42930 1508 42930 {lab=u_cas_diff_out_diff2_b10}
C {./lab_pin.sym} 1508 42930 0 0 {name=l2284_3 lab=u_cas_diff_out_diff2_b10}
N 1712 42870 1732 42870 {lab=VDD}
C {./lab_pin.sym} 1732 42870 0 1 {name=l2284_4 lab=VDD}
N 1712 42890 1732 42890 {lab=VDD}
C {./lab_pin.sym} 1732 42890 0 1 {name=l2284_5 lab=VDD}
N 1712 42910 1732 42910 {lab=VSS}
C {./lab_pin.sym} 1732 42910 0 1 {name=l2284_6 lab=VSS}
N 1712 42930 1732 42930 {lab=VSS}
C {./lab_pin.sym} 1732 42930 0 1 {name=l2284_7 lab=VSS}
C {./dffnrnq_1.sym} 2025 42900 0 0 {name=Xn_2226}
N 1933 42870 1913 42870 {lab=n_0027}
C {./lab_pin.sym} 1913 42870 0 0 {name=l2285_0 lab=n_0027}
N 1933 42890 1913 42890 {lab=net20}
C {./lab_pin.sym} 1913 42890 0 0 {name=l2285_1 lab=net20}
N 1933 42910 1913 42910 {lab=net15}
C {./lab_pin.sym} 1913 42910 0 0 {name=l2285_2 lab=net15}
N 1933 42930 1913 42930 {lab=u_cas_diff_out_diff2_b11}
C {./lab_pin.sym} 1913 42930 0 0 {name=l2285_3 lab=u_cas_diff_out_diff2_b11}
N 2117 42870 2137 42870 {lab=VDD}
C {./lab_pin.sym} 2137 42870 0 1 {name=l2285_4 lab=VDD}
N 2117 42890 2137 42890 {lab=VDD}
C {./lab_pin.sym} 2137 42890 0 1 {name=l2285_5 lab=VDD}
N 2117 42910 2137 42910 {lab=VSS}
C {./lab_pin.sym} 2137 42910 0 1 {name=l2285_6 lab=VSS}
N 2117 42930 2137 42930 {lab=VSS}
C {./lab_pin.sym} 2137 42930 0 1 {name=l2285_7 lab=VSS}
C {./dffnrnq_1.sym} 2430 42900 0 0 {name=Xn_2227}
N 2338 42870 2318 42870 {lab=n_0028}
C {./lab_pin.sym} 2318 42870 0 0 {name=l2286_0 lab=n_0028}
N 2338 42890 2318 42890 {lab=net20}
C {./lab_pin.sym} 2318 42890 0 0 {name=l2286_1 lab=net20}
N 2338 42910 2318 42910 {lab=net15}
C {./lab_pin.sym} 2318 42910 0 0 {name=l2286_2 lab=net15}
N 2338 42930 2318 42930 {lab=u_cas_diff_out_diff2_b12}
C {./lab_pin.sym} 2318 42930 0 0 {name=l2286_3 lab=u_cas_diff_out_diff2_b12}
N 2522 42870 2542 42870 {lab=VDD}
C {./lab_pin.sym} 2542 42870 0 1 {name=l2286_4 lab=VDD}
N 2522 42890 2542 42890 {lab=VDD}
C {./lab_pin.sym} 2542 42890 0 1 {name=l2286_5 lab=VDD}
N 2522 42910 2542 42910 {lab=VSS}
C {./lab_pin.sym} 2542 42910 0 1 {name=l2286_6 lab=VSS}
N 2522 42930 2542 42930 {lab=VSS}
C {./lab_pin.sym} 2542 42930 0 1 {name=l2286_7 lab=VSS}
C {./dffnrnq_1.sym} 2835 42900 0 0 {name=Xn_2228}
N 2743 42870 2723 42870 {lab=n_0029}
C {./lab_pin.sym} 2723 42870 0 0 {name=l2287_0 lab=n_0029}
N 2743 42890 2723 42890 {lab=net20}
C {./lab_pin.sym} 2723 42890 0 0 {name=l2287_1 lab=net20}
N 2743 42910 2723 42910 {lab=net15}
C {./lab_pin.sym} 2723 42910 0 0 {name=l2287_2 lab=net15}
N 2743 42930 2723 42930 {lab=u_cas_diff_out_diff2_b13}
C {./lab_pin.sym} 2723 42930 0 0 {name=l2287_3 lab=u_cas_diff_out_diff2_b13}
N 2927 42870 2947 42870 {lab=VDD}
C {./lab_pin.sym} 2947 42870 0 1 {name=l2287_4 lab=VDD}
N 2927 42890 2947 42890 {lab=VDD}
C {./lab_pin.sym} 2947 42890 0 1 {name=l2287_5 lab=VDD}
N 2927 42910 2947 42910 {lab=VSS}
C {./lab_pin.sym} 2947 42910 0 1 {name=l2287_6 lab=VSS}
N 2927 42930 2947 42930 {lab=VSS}
C {./lab_pin.sym} 2947 42930 0 1 {name=l2287_7 lab=VSS}
C {./dffnrnq_1.sym} 3240 42900 0 0 {name=Xn_2229}
N 3148 42870 3128 42870 {lab=n_0030}
C {./lab_pin.sym} 3128 42870 0 0 {name=l2288_0 lab=n_0030}
N 3148 42890 3128 42890 {lab=net20}
C {./lab_pin.sym} 3128 42890 0 0 {name=l2288_1 lab=net20}
N 3148 42910 3128 42910 {lab=net15}
C {./lab_pin.sym} 3128 42910 0 0 {name=l2288_2 lab=net15}
N 3148 42930 3128 42930 {lab=u_cas_diff_out_diff2_b14}
C {./lab_pin.sym} 3128 42930 0 0 {name=l2288_3 lab=u_cas_diff_out_diff2_b14}
N 3332 42870 3352 42870 {lab=VDD}
C {./lab_pin.sym} 3352 42870 0 1 {name=l2288_4 lab=VDD}
N 3332 42890 3352 42890 {lab=VDD}
C {./lab_pin.sym} 3352 42890 0 1 {name=l2288_5 lab=VDD}
N 3332 42910 3352 42910 {lab=VSS}
C {./lab_pin.sym} 3352 42910 0 1 {name=l2288_6 lab=VSS}
N 3332 42930 3352 42930 {lab=VSS}
C {./lab_pin.sym} 3352 42930 0 1 {name=l2288_7 lab=VSS}
C {./dffnrnq_1.sym} 3645 42900 0 0 {name=Xn_2230}
N 3553 42870 3533 42870 {lab=n_0031}
C {./lab_pin.sym} 3533 42870 0 0 {name=l2289_0 lab=n_0031}
N 3553 42890 3533 42890 {lab=net20}
C {./lab_pin.sym} 3533 42890 0 0 {name=l2289_1 lab=net20}
N 3553 42910 3533 42910 {lab=net15}
C {./lab_pin.sym} 3533 42910 0 0 {name=l2289_2 lab=net15}
N 3553 42930 3533 42930 {lab=u_cas_diff_out_diff2_b15}
C {./lab_pin.sym} 3533 42930 0 0 {name=l2289_3 lab=u_cas_diff_out_diff2_b15}
N 3737 42870 3757 42870 {lab=VDD}
C {./lab_pin.sym} 3757 42870 0 1 {name=l2289_4 lab=VDD}
N 3737 42890 3757 42890 {lab=VDD}
C {./lab_pin.sym} 3757 42890 0 1 {name=l2289_5 lab=VDD}
N 3737 42910 3757 42910 {lab=VSS}
C {./lab_pin.sym} 3757 42910 0 1 {name=l2289_6 lab=VSS}
N 3737 42930 3757 42930 {lab=VSS}
C {./lab_pin.sym} 3757 42930 0 1 {name=l2289_7 lab=VSS}
C {./dffnrnq_1.sym} 4050 42900 0 0 {name=Xn_2231}
N 3958 42870 3938 42870 {lab=n_0032}
C {./lab_pin.sym} 3938 42870 0 0 {name=l2290_0 lab=n_0032}
N 3958 42890 3938 42890 {lab=net20}
C {./lab_pin.sym} 3938 42890 0 0 {name=l2290_1 lab=net20}
N 3958 42910 3938 42910 {lab=net15}
C {./lab_pin.sym} 3938 42910 0 0 {name=l2290_2 lab=net15}
N 3958 42930 3938 42930 {lab=u_cas_diff_out_diff2_b16}
C {./lab_pin.sym} 3938 42930 0 0 {name=l2290_3 lab=u_cas_diff_out_diff2_b16}
N 4142 42870 4162 42870 {lab=VDD}
C {./lab_pin.sym} 4162 42870 0 1 {name=l2290_4 lab=VDD}
N 4142 42890 4162 42890 {lab=VDD}
C {./lab_pin.sym} 4162 42890 0 1 {name=l2290_5 lab=VDD}
N 4142 42910 4162 42910 {lab=VSS}
C {./lab_pin.sym} 4162 42910 0 1 {name=l2290_6 lab=VSS}
N 4142 42930 4162 42930 {lab=VSS}
C {./lab_pin.sym} 4162 42930 0 1 {name=l2290_7 lab=VSS}
C {./dffnrnq_1.sym} 4455 42900 0 0 {name=Xn_2232}
N 4363 42870 4343 42870 {lab=n_0033}
C {./lab_pin.sym} 4343 42870 0 0 {name=l2291_0 lab=n_0033}
N 4363 42890 4343 42890 {lab=net20}
C {./lab_pin.sym} 4343 42890 0 0 {name=l2291_1 lab=net20}
N 4363 42910 4343 42910 {lab=net15}
C {./lab_pin.sym} 4343 42910 0 0 {name=l2291_2 lab=net15}
N 4363 42930 4343 42930 {lab=u_cas_diff_out_diff2_b17}
C {./lab_pin.sym} 4343 42930 0 0 {name=l2291_3 lab=u_cas_diff_out_diff2_b17}
N 4547 42870 4567 42870 {lab=VDD}
C {./lab_pin.sym} 4567 42870 0 1 {name=l2291_4 lab=VDD}
N 4547 42890 4567 42890 {lab=VDD}
C {./lab_pin.sym} 4567 42890 0 1 {name=l2291_5 lab=VDD}
N 4547 42910 4567 42910 {lab=VSS}
C {./lab_pin.sym} 4567 42910 0 1 {name=l2291_6 lab=VSS}
N 4547 42930 4567 42930 {lab=VSS}
C {./lab_pin.sym} 4567 42930 0 1 {name=l2291_7 lab=VSS}
C {./dffnrnq_1.sym} 0 43125 0 0 {name=Xn_2233}
N -92 43095 -112 43095 {lab=n_0034}
C {./lab_pin.sym} -112 43095 0 0 {name=l2292_0 lab=n_0034}
N -92 43115 -112 43115 {lab=net20}
C {./lab_pin.sym} -112 43115 0 0 {name=l2292_1 lab=net20}
N -92 43135 -112 43135 {lab=net15}
C {./lab_pin.sym} -112 43135 0 0 {name=l2292_2 lab=net15}
N -92 43155 -112 43155 {lab=u_cas_diff_out_diff2_b18}
C {./lab_pin.sym} -112 43155 0 0 {name=l2292_3 lab=u_cas_diff_out_diff2_b18}
N 92 43095 112 43095 {lab=VDD}
C {./lab_pin.sym} 112 43095 0 1 {name=l2292_4 lab=VDD}
N 92 43115 112 43115 {lab=VDD}
C {./lab_pin.sym} 112 43115 0 1 {name=l2292_5 lab=VDD}
N 92 43135 112 43135 {lab=VSS}
C {./lab_pin.sym} 112 43135 0 1 {name=l2292_6 lab=VSS}
N 92 43155 112 43155 {lab=VSS}
C {./lab_pin.sym} 112 43155 0 1 {name=l2292_7 lab=VSS}
C {./dffnrnq_1.sym} 405 43125 0 0 {name=Xn_2234}
N 313 43095 293 43095 {lab=n_0035}
C {./lab_pin.sym} 293 43095 0 0 {name=l2293_0 lab=n_0035}
N 313 43115 293 43115 {lab=net20}
C {./lab_pin.sym} 293 43115 0 0 {name=l2293_1 lab=net20}
N 313 43135 293 43135 {lab=net15}
C {./lab_pin.sym} 293 43135 0 0 {name=l2293_2 lab=net15}
N 313 43155 293 43155 {lab=u_cas_diff_out_diff2_b19}
C {./lab_pin.sym} 293 43155 0 0 {name=l2293_3 lab=u_cas_diff_out_diff2_b19}
N 497 43095 517 43095 {lab=VDD}
C {./lab_pin.sym} 517 43095 0 1 {name=l2293_4 lab=VDD}
N 497 43115 517 43115 {lab=VDD}
C {./lab_pin.sym} 517 43115 0 1 {name=l2293_5 lab=VDD}
N 497 43135 517 43135 {lab=VSS}
C {./lab_pin.sym} 517 43135 0 1 {name=l2293_6 lab=VSS}
N 497 43155 517 43155 {lab=VSS}
C {./lab_pin.sym} 517 43155 0 1 {name=l2293_7 lab=VSS}
C {./dffnrnq_1.sym} 810 43125 0 0 {name=Xn_2235}
N 718 43095 698 43095 {lab=n_0037}
C {./lab_pin.sym} 698 43095 0 0 {name=l2294_0 lab=n_0037}
N 718 43115 698 43115 {lab=net20}
C {./lab_pin.sym} 698 43115 0 0 {name=l2294_1 lab=net20}
N 718 43135 698 43135 {lab=net15}
C {./lab_pin.sym} 698 43135 0 0 {name=l2294_2 lab=net15}
N 718 43155 698 43155 {lab=u_cas_diff_out_diff2_b20}
C {./lab_pin.sym} 698 43155 0 0 {name=l2294_3 lab=u_cas_diff_out_diff2_b20}
N 902 43095 922 43095 {lab=VDD}
C {./lab_pin.sym} 922 43095 0 1 {name=l2294_4 lab=VDD}
N 902 43115 922 43115 {lab=VDD}
C {./lab_pin.sym} 922 43115 0 1 {name=l2294_5 lab=VDD}
N 902 43135 922 43135 {lab=VSS}
C {./lab_pin.sym} 922 43135 0 1 {name=l2294_6 lab=VSS}
N 902 43155 922 43155 {lab=VSS}
C {./lab_pin.sym} 922 43155 0 1 {name=l2294_7 lab=VSS}
C {./dffnrnq_1.sym} 1215 43125 0 0 {name=Xn_2236}
N 1123 43095 1103 43095 {lab=n_0038}
C {./lab_pin.sym} 1103 43095 0 0 {name=l2295_0 lab=n_0038}
N 1123 43115 1103 43115 {lab=net20}
C {./lab_pin.sym} 1103 43115 0 0 {name=l2295_1 lab=net20}
N 1123 43135 1103 43135 {lab=net15}
C {./lab_pin.sym} 1103 43135 0 0 {name=l2295_2 lab=net15}
N 1123 43155 1103 43155 {lab=u_cas_diff_out_diff2_b21}
C {./lab_pin.sym} 1103 43155 0 0 {name=l2295_3 lab=u_cas_diff_out_diff2_b21}
N 1307 43095 1327 43095 {lab=VDD}
C {./lab_pin.sym} 1327 43095 0 1 {name=l2295_4 lab=VDD}
N 1307 43115 1327 43115 {lab=VDD}
C {./lab_pin.sym} 1327 43115 0 1 {name=l2295_5 lab=VDD}
N 1307 43135 1327 43135 {lab=VSS}
C {./lab_pin.sym} 1327 43135 0 1 {name=l2295_6 lab=VSS}
N 1307 43155 1327 43155 {lab=VSS}
C {./lab_pin.sym} 1327 43155 0 1 {name=l2295_7 lab=VSS}
C {./dffnrnq_1.sym} 1620 43125 0 0 {name=Xn_2237}
N 1528 43095 1508 43095 {lab=n_0039}
C {./lab_pin.sym} 1508 43095 0 0 {name=l2296_0 lab=n_0039}
N 1528 43115 1508 43115 {lab=net20}
C {./lab_pin.sym} 1508 43115 0 0 {name=l2296_1 lab=net20}
N 1528 43135 1508 43135 {lab=net15}
C {./lab_pin.sym} 1508 43135 0 0 {name=l2296_2 lab=net15}
N 1528 43155 1508 43155 {lab=u_cas_diff_out_diff2_b22}
C {./lab_pin.sym} 1508 43155 0 0 {name=l2296_3 lab=u_cas_diff_out_diff2_b22}
N 1712 43095 1732 43095 {lab=VDD}
C {./lab_pin.sym} 1732 43095 0 1 {name=l2296_4 lab=VDD}
N 1712 43115 1732 43115 {lab=VDD}
C {./lab_pin.sym} 1732 43115 0 1 {name=l2296_5 lab=VDD}
N 1712 43135 1732 43135 {lab=VSS}
C {./lab_pin.sym} 1732 43135 0 1 {name=l2296_6 lab=VSS}
N 1712 43155 1732 43155 {lab=VSS}
C {./lab_pin.sym} 1732 43155 0 1 {name=l2296_7 lab=VSS}
C {./dffnrnq_1.sym} 2025 43125 0 0 {name=Xn_2238}
N 1933 43095 1913 43095 {lab=n_0040}
C {./lab_pin.sym} 1913 43095 0 0 {name=l2297_0 lab=n_0040}
N 1933 43115 1913 43115 {lab=net20}
C {./lab_pin.sym} 1913 43115 0 0 {name=l2297_1 lab=net20}
N 1933 43135 1913 43135 {lab=net15}
C {./lab_pin.sym} 1913 43135 0 0 {name=l2297_2 lab=net15}
N 1933 43155 1913 43155 {lab=u_cas_diff_out_diff2_b23}
C {./lab_pin.sym} 1913 43155 0 0 {name=l2297_3 lab=u_cas_diff_out_diff2_b23}
N 2117 43095 2137 43095 {lab=VDD}
C {./lab_pin.sym} 2137 43095 0 1 {name=l2297_4 lab=VDD}
N 2117 43115 2137 43115 {lab=VDD}
C {./lab_pin.sym} 2137 43115 0 1 {name=l2297_5 lab=VDD}
N 2117 43135 2137 43135 {lab=VSS}
C {./lab_pin.sym} 2137 43135 0 1 {name=l2297_6 lab=VSS}
N 2117 43155 2137 43155 {lab=VSS}
C {./lab_pin.sym} 2137 43155 0 1 {name=l2297_7 lab=VSS}
C {./dffnrnq_1.sym} 2430 43125 0 0 {name=Xn_2239}
N 2338 43095 2318 43095 {lab=n_0041}
C {./lab_pin.sym} 2318 43095 0 0 {name=l2298_0 lab=n_0041}
N 2338 43115 2318 43115 {lab=net20}
C {./lab_pin.sym} 2318 43115 0 0 {name=l2298_1 lab=net20}
N 2338 43135 2318 43135 {lab=net15}
C {./lab_pin.sym} 2318 43135 0 0 {name=l2298_2 lab=net15}
N 2338 43155 2318 43155 {lab=u_cas_diff_out_diff2_b24}
C {./lab_pin.sym} 2318 43155 0 0 {name=l2298_3 lab=u_cas_diff_out_diff2_b24}
N 2522 43095 2542 43095 {lab=VDD}
C {./lab_pin.sym} 2542 43095 0 1 {name=l2298_4 lab=VDD}
N 2522 43115 2542 43115 {lab=VDD}
C {./lab_pin.sym} 2542 43115 0 1 {name=l2298_5 lab=VDD}
N 2522 43135 2542 43135 {lab=VSS}
C {./lab_pin.sym} 2542 43135 0 1 {name=l2298_6 lab=VSS}
N 2522 43155 2542 43155 {lab=VSS}
C {./lab_pin.sym} 2542 43155 0 1 {name=l2298_7 lab=VSS}
C {./dffnrnq_1.sym} 2835 43125 0 0 {name=Xn_2240}
N 2743 43095 2723 43095 {lab=out_cas_int_b0}
C {./lab_pin.sym} 2723 43095 0 0 {name=l2299_0 lab=out_cas_int_b0}
N 2743 43115 2723 43115 {lab=net21}
C {./lab_pin.sym} 2723 43115 0 0 {name=l2299_1 lab=net21}
N 2743 43135 2723 43135 {lab=net16}
C {./lab_pin.sym} 2723 43135 0 0 {name=l2299_2 lab=net16}
N 2743 43155 2723 43155 {lab=u_cas_diff_u_diff1_in_min1_b0}
C {./lab_pin.sym} 2723 43155 0 0 {name=l2299_3 lab=u_cas_diff_u_diff1_in_min1_b0}
N 2927 43095 2947 43095 {lab=VDD}
C {./lab_pin.sym} 2947 43095 0 1 {name=l2299_4 lab=VDD}
N 2927 43115 2947 43115 {lab=VDD}
C {./lab_pin.sym} 2947 43115 0 1 {name=l2299_5 lab=VDD}
N 2927 43135 2947 43135 {lab=VSS}
C {./lab_pin.sym} 2947 43135 0 1 {name=l2299_6 lab=VSS}
N 2927 43155 2947 43155 {lab=VSS}
C {./lab_pin.sym} 2947 43155 0 1 {name=l2299_7 lab=VSS}
C {./dffnrnq_1.sym} 3240 43125 0 0 {name=Xn_2241}
N 3148 43095 3128 43095 {lab=out_cas_int_b1}
C {./lab_pin.sym} 3128 43095 0 0 {name=l2300_0 lab=out_cas_int_b1}
N 3148 43115 3128 43115 {lab=net21}
C {./lab_pin.sym} 3128 43115 0 0 {name=l2300_1 lab=net21}
N 3148 43135 3128 43135 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 3128 43135 0 0 {name=l2300_2 lab=u_clock_div_counter_b7}
N 3148 43155 3128 43155 {lab=u_cas_diff_u_diff1_in_min1_b1}
C {./lab_pin.sym} 3128 43155 0 0 {name=l2300_3 lab=u_cas_diff_u_diff1_in_min1_b1}
N 3332 43095 3352 43095 {lab=VDD}
C {./lab_pin.sym} 3352 43095 0 1 {name=l2300_4 lab=VDD}
N 3332 43115 3352 43115 {lab=VDD}
C {./lab_pin.sym} 3352 43115 0 1 {name=l2300_5 lab=VDD}
N 3332 43135 3352 43135 {lab=VSS}
C {./lab_pin.sym} 3352 43135 0 1 {name=l2300_6 lab=VSS}
N 3332 43155 3352 43155 {lab=VSS}
C {./lab_pin.sym} 3352 43155 0 1 {name=l2300_7 lab=VSS}
C {./dffnrnq_1.sym} 3645 43125 0 0 {name=Xn_2242}
N 3553 43095 3533 43095 {lab=out_cas_int_b2}
C {./lab_pin.sym} 3533 43095 0 0 {name=l2301_0 lab=out_cas_int_b2}
N 3553 43115 3533 43115 {lab=net18}
C {./lab_pin.sym} 3533 43115 0 0 {name=l2301_1 lab=net18}
N 3553 43135 3533 43135 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 3533 43135 0 0 {name=l2301_2 lab=u_clock_div_counter_b7}
N 3553 43155 3533 43155 {lab=u_cas_diff_u_diff1_in_min1_b2}
C {./lab_pin.sym} 3533 43155 0 0 {name=l2301_3 lab=u_cas_diff_u_diff1_in_min1_b2}
N 3737 43095 3757 43095 {lab=VDD}
C {./lab_pin.sym} 3757 43095 0 1 {name=l2301_4 lab=VDD}
N 3737 43115 3757 43115 {lab=VDD}
C {./lab_pin.sym} 3757 43115 0 1 {name=l2301_5 lab=VDD}
N 3737 43135 3757 43135 {lab=VSS}
C {./lab_pin.sym} 3757 43135 0 1 {name=l2301_6 lab=VSS}
N 3737 43155 3757 43155 {lab=VSS}
C {./lab_pin.sym} 3757 43155 0 1 {name=l2301_7 lab=VSS}
C {./dffnrnq_1.sym} 4050 43125 0 0 {name=Xn_2243}
N 3958 43095 3938 43095 {lab=out_cas_int_b3}
C {./lab_pin.sym} 3938 43095 0 0 {name=l2302_0 lab=out_cas_int_b3}
N 3958 43115 3938 43115 {lab=net18}
C {./lab_pin.sym} 3938 43115 0 0 {name=l2302_1 lab=net18}
N 3958 43135 3938 43135 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 3938 43135 0 0 {name=l2302_2 lab=u_clock_div_counter_b7}
N 3958 43155 3938 43155 {lab=u_cas_diff_u_diff1_in_min1_b3}
C {./lab_pin.sym} 3938 43155 0 0 {name=l2302_3 lab=u_cas_diff_u_diff1_in_min1_b3}
N 4142 43095 4162 43095 {lab=VDD}
C {./lab_pin.sym} 4162 43095 0 1 {name=l2302_4 lab=VDD}
N 4142 43115 4162 43115 {lab=VDD}
C {./lab_pin.sym} 4162 43115 0 1 {name=l2302_5 lab=VDD}
N 4142 43135 4162 43135 {lab=VSS}
C {./lab_pin.sym} 4162 43135 0 1 {name=l2302_6 lab=VSS}
N 4142 43155 4162 43155 {lab=VSS}
C {./lab_pin.sym} 4162 43155 0 1 {name=l2302_7 lab=VSS}
C {./dffnrnq_1.sym} 4455 43125 0 0 {name=Xn_2244}
N 4363 43095 4343 43095 {lab=out_cas_int_b4}
C {./lab_pin.sym} 4343 43095 0 0 {name=l2303_0 lab=out_cas_int_b4}
N 4363 43115 4343 43115 {lab=net18}
C {./lab_pin.sym} 4343 43115 0 0 {name=l2303_1 lab=net18}
N 4363 43135 4343 43135 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 4343 43135 0 0 {name=l2303_2 lab=u_clock_div_counter_b7}
N 4363 43155 4343 43155 {lab=u_cas_diff_u_diff1_in_min1_b4}
C {./lab_pin.sym} 4343 43155 0 0 {name=l2303_3 lab=u_cas_diff_u_diff1_in_min1_b4}
N 4547 43095 4567 43095 {lab=VDD}
C {./lab_pin.sym} 4567 43095 0 1 {name=l2303_4 lab=VDD}
N 4547 43115 4567 43115 {lab=VDD}
C {./lab_pin.sym} 4567 43115 0 1 {name=l2303_5 lab=VDD}
N 4547 43135 4567 43135 {lab=VSS}
C {./lab_pin.sym} 4567 43135 0 1 {name=l2303_6 lab=VSS}
N 4547 43155 4567 43155 {lab=VSS}
C {./lab_pin.sym} 4567 43155 0 1 {name=l2303_7 lab=VSS}
C {./dffnrnq_1.sym} 0 43350 0 0 {name=Xn_2245}
N -92 43320 -112 43320 {lab=out_cas_int_b5}
C {./lab_pin.sym} -112 43320 0 0 {name=l2304_0 lab=out_cas_int_b5}
N -92 43340 -112 43340 {lab=net18}
C {./lab_pin.sym} -112 43340 0 0 {name=l2304_1 lab=net18}
N -92 43360 -112 43360 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} -112 43360 0 0 {name=l2304_2 lab=u_clock_div_counter_b7}
N -92 43380 -112 43380 {lab=u_cas_diff_u_diff1_in_min1_b5}
C {./lab_pin.sym} -112 43380 0 0 {name=l2304_3 lab=u_cas_diff_u_diff1_in_min1_b5}
N 92 43320 112 43320 {lab=VDD}
C {./lab_pin.sym} 112 43320 0 1 {name=l2304_4 lab=VDD}
N 92 43340 112 43340 {lab=VDD}
C {./lab_pin.sym} 112 43340 0 1 {name=l2304_5 lab=VDD}
N 92 43360 112 43360 {lab=VSS}
C {./lab_pin.sym} 112 43360 0 1 {name=l2304_6 lab=VSS}
N 92 43380 112 43380 {lab=VSS}
C {./lab_pin.sym} 112 43380 0 1 {name=l2304_7 lab=VSS}
C {./dffnrnq_1.sym} 405 43350 0 0 {name=Xn_2246}
N 313 43320 293 43320 {lab=out_cas_int_b6}
C {./lab_pin.sym} 293 43320 0 0 {name=l2305_0 lab=out_cas_int_b6}
N 313 43340 293 43340 {lab=net18}
C {./lab_pin.sym} 293 43340 0 0 {name=l2305_1 lab=net18}
N 313 43360 293 43360 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 293 43360 0 0 {name=l2305_2 lab=u_clock_div_counter_b7}
N 313 43380 293 43380 {lab=u_cas_diff_u_diff1_in_min1_b6}
C {./lab_pin.sym} 293 43380 0 0 {name=l2305_3 lab=u_cas_diff_u_diff1_in_min1_b6}
N 497 43320 517 43320 {lab=VDD}
C {./lab_pin.sym} 517 43320 0 1 {name=l2305_4 lab=VDD}
N 497 43340 517 43340 {lab=VDD}
C {./lab_pin.sym} 517 43340 0 1 {name=l2305_5 lab=VDD}
N 497 43360 517 43360 {lab=VSS}
C {./lab_pin.sym} 517 43360 0 1 {name=l2305_6 lab=VSS}
N 497 43380 517 43380 {lab=VSS}
C {./lab_pin.sym} 517 43380 0 1 {name=l2305_7 lab=VSS}
C {./dffnrnq_1.sym} 810 43350 0 0 {name=Xn_2247}
N 718 43320 698 43320 {lab=out_cas_int_b7}
C {./lab_pin.sym} 698 43320 0 0 {name=l2306_0 lab=out_cas_int_b7}
N 718 43340 698 43340 {lab=net18}
C {./lab_pin.sym} 698 43340 0 0 {name=l2306_1 lab=net18}
N 718 43360 698 43360 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 698 43360 0 0 {name=l2306_2 lab=u_clock_div_counter_b7}
N 718 43380 698 43380 {lab=u_cas_diff_u_diff1_in_min1_b7}
C {./lab_pin.sym} 698 43380 0 0 {name=l2306_3 lab=u_cas_diff_u_diff1_in_min1_b7}
N 902 43320 922 43320 {lab=VDD}
C {./lab_pin.sym} 922 43320 0 1 {name=l2306_4 lab=VDD}
N 902 43340 922 43340 {lab=VDD}
C {./lab_pin.sym} 922 43340 0 1 {name=l2306_5 lab=VDD}
N 902 43360 922 43360 {lab=VSS}
C {./lab_pin.sym} 922 43360 0 1 {name=l2306_6 lab=VSS}
N 902 43380 922 43380 {lab=VSS}
C {./lab_pin.sym} 922 43380 0 1 {name=l2306_7 lab=VSS}
C {./dffnrnq_1.sym} 1215 43350 0 0 {name=Xn_2248}
N 1123 43320 1103 43320 {lab=out_cas_int_b8}
C {./lab_pin.sym} 1103 43320 0 0 {name=l2307_0 lab=out_cas_int_b8}
N 1123 43340 1103 43340 {lab=net18}
C {./lab_pin.sym} 1103 43340 0 0 {name=l2307_1 lab=net18}
N 1123 43360 1103 43360 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 1103 43360 0 0 {name=l2307_2 lab=u_clock_div_counter_b7}
N 1123 43380 1103 43380 {lab=u_cas_diff_u_diff1_in_min1_b8}
C {./lab_pin.sym} 1103 43380 0 0 {name=l2307_3 lab=u_cas_diff_u_diff1_in_min1_b8}
N 1307 43320 1327 43320 {lab=VDD}
C {./lab_pin.sym} 1327 43320 0 1 {name=l2307_4 lab=VDD}
N 1307 43340 1327 43340 {lab=VDD}
C {./lab_pin.sym} 1327 43340 0 1 {name=l2307_5 lab=VDD}
N 1307 43360 1327 43360 {lab=VSS}
C {./lab_pin.sym} 1327 43360 0 1 {name=l2307_6 lab=VSS}
N 1307 43380 1327 43380 {lab=VSS}
C {./lab_pin.sym} 1327 43380 0 1 {name=l2307_7 lab=VSS}
C {./dffnrnq_1.sym} 1620 43350 0 0 {name=Xn_2249}
N 1528 43320 1508 43320 {lab=out_cas_int_b9}
C {./lab_pin.sym} 1508 43320 0 0 {name=l2308_0 lab=out_cas_int_b9}
N 1528 43340 1508 43340 {lab=net18}
C {./lab_pin.sym} 1508 43340 0 0 {name=l2308_1 lab=net18}
N 1528 43360 1508 43360 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 1508 43360 0 0 {name=l2308_2 lab=u_clock_div_counter_b7}
N 1528 43380 1508 43380 {lab=u_cas_diff_u_diff1_in_min1_b9}
C {./lab_pin.sym} 1508 43380 0 0 {name=l2308_3 lab=u_cas_diff_u_diff1_in_min1_b9}
N 1712 43320 1732 43320 {lab=VDD}
C {./lab_pin.sym} 1732 43320 0 1 {name=l2308_4 lab=VDD}
N 1712 43340 1732 43340 {lab=VDD}
C {./lab_pin.sym} 1732 43340 0 1 {name=l2308_5 lab=VDD}
N 1712 43360 1732 43360 {lab=VSS}
C {./lab_pin.sym} 1732 43360 0 1 {name=l2308_6 lab=VSS}
N 1712 43380 1732 43380 {lab=VSS}
C {./lab_pin.sym} 1732 43380 0 1 {name=l2308_7 lab=VSS}
C {./dffnrnq_1.sym} 2025 43350 0 0 {name=Xn_2250}
N 1933 43320 1913 43320 {lab=out_cas_int_b10}
C {./lab_pin.sym} 1913 43320 0 0 {name=l2309_0 lab=out_cas_int_b10}
N 1933 43340 1913 43340 {lab=net18}
C {./lab_pin.sym} 1913 43340 0 0 {name=l2309_1 lab=net18}
N 1933 43360 1913 43360 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 1913 43360 0 0 {name=l2309_2 lab=u_clock_div_counter_b7}
N 1933 43380 1913 43380 {lab=u_cas_diff_u_diff1_in_min1_b10}
C {./lab_pin.sym} 1913 43380 0 0 {name=l2309_3 lab=u_cas_diff_u_diff1_in_min1_b10}
N 2117 43320 2137 43320 {lab=VDD}
C {./lab_pin.sym} 2137 43320 0 1 {name=l2309_4 lab=VDD}
N 2117 43340 2137 43340 {lab=VDD}
C {./lab_pin.sym} 2137 43340 0 1 {name=l2309_5 lab=VDD}
N 2117 43360 2137 43360 {lab=VSS}
C {./lab_pin.sym} 2137 43360 0 1 {name=l2309_6 lab=VSS}
N 2117 43380 2137 43380 {lab=VSS}
C {./lab_pin.sym} 2137 43380 0 1 {name=l2309_7 lab=VSS}
C {./dffnrnq_1.sym} 2430 43350 0 0 {name=Xn_2251}
N 2338 43320 2318 43320 {lab=out_cas_int_b11}
C {./lab_pin.sym} 2318 43320 0 0 {name=l2310_0 lab=out_cas_int_b11}
N 2338 43340 2318 43340 {lab=net18}
C {./lab_pin.sym} 2318 43340 0 0 {name=l2310_1 lab=net18}
N 2338 43360 2318 43360 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 2318 43360 0 0 {name=l2310_2 lab=u_clock_div_counter_b7}
N 2338 43380 2318 43380 {lab=u_cas_diff_u_diff1_in_min1_b11}
C {./lab_pin.sym} 2318 43380 0 0 {name=l2310_3 lab=u_cas_diff_u_diff1_in_min1_b11}
N 2522 43320 2542 43320 {lab=VDD}
C {./lab_pin.sym} 2542 43320 0 1 {name=l2310_4 lab=VDD}
N 2522 43340 2542 43340 {lab=VDD}
C {./lab_pin.sym} 2542 43340 0 1 {name=l2310_5 lab=VDD}
N 2522 43360 2542 43360 {lab=VSS}
C {./lab_pin.sym} 2542 43360 0 1 {name=l2310_6 lab=VSS}
N 2522 43380 2542 43380 {lab=VSS}
C {./lab_pin.sym} 2542 43380 0 1 {name=l2310_7 lab=VSS}
C {./dffnrnq_1.sym} 2835 43350 0 0 {name=Xn_2252}
N 2743 43320 2723 43320 {lab=out_cas_int_b12}
C {./lab_pin.sym} 2723 43320 0 0 {name=l2311_0 lab=out_cas_int_b12}
N 2743 43340 2723 43340 {lab=net18}
C {./lab_pin.sym} 2723 43340 0 0 {name=l2311_1 lab=net18}
N 2743 43360 2723 43360 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 2723 43360 0 0 {name=l2311_2 lab=u_clock_div_counter_b7}
N 2743 43380 2723 43380 {lab=u_cas_diff_u_diff1_in_min1_b12}
C {./lab_pin.sym} 2723 43380 0 0 {name=l2311_3 lab=u_cas_diff_u_diff1_in_min1_b12}
N 2927 43320 2947 43320 {lab=VDD}
C {./lab_pin.sym} 2947 43320 0 1 {name=l2311_4 lab=VDD}
N 2927 43340 2947 43340 {lab=VDD}
C {./lab_pin.sym} 2947 43340 0 1 {name=l2311_5 lab=VDD}
N 2927 43360 2947 43360 {lab=VSS}
C {./lab_pin.sym} 2947 43360 0 1 {name=l2311_6 lab=VSS}
N 2927 43380 2947 43380 {lab=VSS}
C {./lab_pin.sym} 2947 43380 0 1 {name=l2311_7 lab=VSS}
C {./dffnrnq_1.sym} 3240 43350 0 0 {name=Xn_2253}
N 3148 43320 3128 43320 {lab=out_cas_int_b13}
C {./lab_pin.sym} 3128 43320 0 0 {name=l2312_0 lab=out_cas_int_b13}
N 3148 43340 3128 43340 {lab=net18}
C {./lab_pin.sym} 3128 43340 0 0 {name=l2312_1 lab=net18}
N 3148 43360 3128 43360 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 3128 43360 0 0 {name=l2312_2 lab=u_clock_div_counter_b7}
N 3148 43380 3128 43380 {lab=u_cas_diff_u_diff1_in_min1_b13}
C {./lab_pin.sym} 3128 43380 0 0 {name=l2312_3 lab=u_cas_diff_u_diff1_in_min1_b13}
N 3332 43320 3352 43320 {lab=VDD}
C {./lab_pin.sym} 3352 43320 0 1 {name=l2312_4 lab=VDD}
N 3332 43340 3352 43340 {lab=VDD}
C {./lab_pin.sym} 3352 43340 0 1 {name=l2312_5 lab=VDD}
N 3332 43360 3352 43360 {lab=VSS}
C {./lab_pin.sym} 3352 43360 0 1 {name=l2312_6 lab=VSS}
N 3332 43380 3352 43380 {lab=VSS}
C {./lab_pin.sym} 3352 43380 0 1 {name=l2312_7 lab=VSS}
C {./dffnrnq_1.sym} 3645 43350 0 0 {name=Xn_2254}
N 3553 43320 3533 43320 {lab=out_cas_int_b14}
C {./lab_pin.sym} 3533 43320 0 0 {name=l2313_0 lab=out_cas_int_b14}
N 3553 43340 3533 43340 {lab=net18}
C {./lab_pin.sym} 3533 43340 0 0 {name=l2313_1 lab=net18}
N 3553 43360 3533 43360 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 3533 43360 0 0 {name=l2313_2 lab=u_clock_div_counter_b7}
N 3553 43380 3533 43380 {lab=u_cas_diff_u_diff1_in_min1_b14}
C {./lab_pin.sym} 3533 43380 0 0 {name=l2313_3 lab=u_cas_diff_u_diff1_in_min1_b14}
N 3737 43320 3757 43320 {lab=VDD}
C {./lab_pin.sym} 3757 43320 0 1 {name=l2313_4 lab=VDD}
N 3737 43340 3757 43340 {lab=VDD}
C {./lab_pin.sym} 3757 43340 0 1 {name=l2313_5 lab=VDD}
N 3737 43360 3757 43360 {lab=VSS}
C {./lab_pin.sym} 3757 43360 0 1 {name=l2313_6 lab=VSS}
N 3737 43380 3757 43380 {lab=VSS}
C {./lab_pin.sym} 3757 43380 0 1 {name=l2313_7 lab=VSS}
C {./dffnrnq_1.sym} 4050 43350 0 0 {name=Xn_2255}
N 3958 43320 3938 43320 {lab=out_cas_int_b15}
C {./lab_pin.sym} 3938 43320 0 0 {name=l2314_0 lab=out_cas_int_b15}
N 3958 43340 3938 43340 {lab=net18}
C {./lab_pin.sym} 3938 43340 0 0 {name=l2314_1 lab=net18}
N 3958 43360 3938 43360 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 3938 43360 0 0 {name=l2314_2 lab=u_clock_div_counter_b7}
N 3958 43380 3938 43380 {lab=u_cas_diff_u_diff1_in_min1_b15}
C {./lab_pin.sym} 3938 43380 0 0 {name=l2314_3 lab=u_cas_diff_u_diff1_in_min1_b15}
N 4142 43320 4162 43320 {lab=VDD}
C {./lab_pin.sym} 4162 43320 0 1 {name=l2314_4 lab=VDD}
N 4142 43340 4162 43340 {lab=VDD}
C {./lab_pin.sym} 4162 43340 0 1 {name=l2314_5 lab=VDD}
N 4142 43360 4162 43360 {lab=VSS}
C {./lab_pin.sym} 4162 43360 0 1 {name=l2314_6 lab=VSS}
N 4142 43380 4162 43380 {lab=VSS}
C {./lab_pin.sym} 4162 43380 0 1 {name=l2314_7 lab=VSS}
C {./dffnrnq_1.sym} 4455 43350 0 0 {name=Xn_2256}
N 4363 43320 4343 43320 {lab=out_cas_int_b16}
C {./lab_pin.sym} 4343 43320 0 0 {name=l2315_0 lab=out_cas_int_b16}
N 4363 43340 4343 43340 {lab=net18}
C {./lab_pin.sym} 4343 43340 0 0 {name=l2315_1 lab=net18}
N 4363 43360 4343 43360 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 4343 43360 0 0 {name=l2315_2 lab=u_clock_div_counter_b7}
N 4363 43380 4343 43380 {lab=u_cas_diff_u_diff1_in_min1_b16}
C {./lab_pin.sym} 4343 43380 0 0 {name=l2315_3 lab=u_cas_diff_u_diff1_in_min1_b16}
N 4547 43320 4567 43320 {lab=VDD}
C {./lab_pin.sym} 4567 43320 0 1 {name=l2315_4 lab=VDD}
N 4547 43340 4567 43340 {lab=VDD}
C {./lab_pin.sym} 4567 43340 0 1 {name=l2315_5 lab=VDD}
N 4547 43360 4567 43360 {lab=VSS}
C {./lab_pin.sym} 4567 43360 0 1 {name=l2315_6 lab=VSS}
N 4547 43380 4567 43380 {lab=VSS}
C {./lab_pin.sym} 4567 43380 0 1 {name=l2315_7 lab=VSS}
C {./dffnrnq_1.sym} 0 43575 0 0 {name=Xn_2257}
N -92 43545 -112 43545 {lab=out_cas_int_b17}
C {./lab_pin.sym} -112 43545 0 0 {name=l2316_0 lab=out_cas_int_b17}
N -92 43565 -112 43565 {lab=net18}
C {./lab_pin.sym} -112 43565 0 0 {name=l2316_1 lab=net18}
N -92 43585 -112 43585 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} -112 43585 0 0 {name=l2316_2 lab=u_clock_div_counter_b7}
N -92 43605 -112 43605 {lab=u_cas_diff_u_diff1_in_min1_b17}
C {./lab_pin.sym} -112 43605 0 0 {name=l2316_3 lab=u_cas_diff_u_diff1_in_min1_b17}
N 92 43545 112 43545 {lab=VDD}
C {./lab_pin.sym} 112 43545 0 1 {name=l2316_4 lab=VDD}
N 92 43565 112 43565 {lab=VDD}
C {./lab_pin.sym} 112 43565 0 1 {name=l2316_5 lab=VDD}
N 92 43585 112 43585 {lab=VSS}
C {./lab_pin.sym} 112 43585 0 1 {name=l2316_6 lab=VSS}
N 92 43605 112 43605 {lab=VSS}
C {./lab_pin.sym} 112 43605 0 1 {name=l2316_7 lab=VSS}
C {./dffnrnq_1.sym} 405 43575 0 0 {name=Xn_2258}
N 313 43545 293 43545 {lab=out_cas_int_b18}
C {./lab_pin.sym} 293 43545 0 0 {name=l2317_0 lab=out_cas_int_b18}
N 313 43565 293 43565 {lab=net18}
C {./lab_pin.sym} 293 43565 0 0 {name=l2317_1 lab=net18}
N 313 43585 293 43585 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 293 43585 0 0 {name=l2317_2 lab=u_clock_div_counter_b7}
N 313 43605 293 43605 {lab=u_cas_diff_u_diff1_in_min1_b18}
C {./lab_pin.sym} 293 43605 0 0 {name=l2317_3 lab=u_cas_diff_u_diff1_in_min1_b18}
N 497 43545 517 43545 {lab=VDD}
C {./lab_pin.sym} 517 43545 0 1 {name=l2317_4 lab=VDD}
N 497 43565 517 43565 {lab=VDD}
C {./lab_pin.sym} 517 43565 0 1 {name=l2317_5 lab=VDD}
N 497 43585 517 43585 {lab=VSS}
C {./lab_pin.sym} 517 43585 0 1 {name=l2317_6 lab=VSS}
N 497 43605 517 43605 {lab=VSS}
C {./lab_pin.sym} 517 43605 0 1 {name=l2317_7 lab=VSS}
C {./dffnrnq_1.sym} 810 43575 0 0 {name=Xn_2259}
N 718 43545 698 43545 {lab=out_cas_int_b19}
C {./lab_pin.sym} 698 43545 0 0 {name=l2318_0 lab=out_cas_int_b19}
N 718 43565 698 43565 {lab=net18}
C {./lab_pin.sym} 698 43565 0 0 {name=l2318_1 lab=net18}
N 718 43585 698 43585 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 698 43585 0 0 {name=l2318_2 lab=u_clock_div_counter_b7}
N 718 43605 698 43605 {lab=u_cas_diff_u_diff1_in_min1_b19}
C {./lab_pin.sym} 698 43605 0 0 {name=l2318_3 lab=u_cas_diff_u_diff1_in_min1_b19}
N 902 43545 922 43545 {lab=VDD}
C {./lab_pin.sym} 922 43545 0 1 {name=l2318_4 lab=VDD}
N 902 43565 922 43565 {lab=VDD}
C {./lab_pin.sym} 922 43565 0 1 {name=l2318_5 lab=VDD}
N 902 43585 922 43585 {lab=VSS}
C {./lab_pin.sym} 922 43585 0 1 {name=l2318_6 lab=VSS}
N 902 43605 922 43605 {lab=VSS}
C {./lab_pin.sym} 922 43605 0 1 {name=l2318_7 lab=VSS}
C {./dffnrnq_1.sym} 1215 43575 0 0 {name=Xn_2260}
N 1123 43545 1103 43545 {lab=out_cas_int_b20}
C {./lab_pin.sym} 1103 43545 0 0 {name=l2319_0 lab=out_cas_int_b20}
N 1123 43565 1103 43565 {lab=net18}
C {./lab_pin.sym} 1103 43565 0 0 {name=l2319_1 lab=net18}
N 1123 43585 1103 43585 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 1103 43585 0 0 {name=l2319_2 lab=u_clock_div_counter_b7}
N 1123 43605 1103 43605 {lab=u_cas_diff_u_diff1_in_min1_b20}
C {./lab_pin.sym} 1103 43605 0 0 {name=l2319_3 lab=u_cas_diff_u_diff1_in_min1_b20}
N 1307 43545 1327 43545 {lab=VDD}
C {./lab_pin.sym} 1327 43545 0 1 {name=l2319_4 lab=VDD}
N 1307 43565 1327 43565 {lab=VDD}
C {./lab_pin.sym} 1327 43565 0 1 {name=l2319_5 lab=VDD}
N 1307 43585 1327 43585 {lab=VSS}
C {./lab_pin.sym} 1327 43585 0 1 {name=l2319_6 lab=VSS}
N 1307 43605 1327 43605 {lab=VSS}
C {./lab_pin.sym} 1327 43605 0 1 {name=l2319_7 lab=VSS}
C {./dffnrnq_1.sym} 1620 43575 0 0 {name=Xn_2261}
N 1528 43545 1508 43545 {lab=out_cas_int_b21}
C {./lab_pin.sym} 1508 43545 0 0 {name=l2320_0 lab=out_cas_int_b21}
N 1528 43565 1508 43565 {lab=net18}
C {./lab_pin.sym} 1508 43565 0 0 {name=l2320_1 lab=net18}
N 1528 43585 1508 43585 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 1508 43585 0 0 {name=l2320_2 lab=u_clock_div_counter_b7}
N 1528 43605 1508 43605 {lab=u_cas_diff_u_diff1_in_min1_b21}
C {./lab_pin.sym} 1508 43605 0 0 {name=l2320_3 lab=u_cas_diff_u_diff1_in_min1_b21}
N 1712 43545 1732 43545 {lab=VDD}
C {./lab_pin.sym} 1732 43545 0 1 {name=l2320_4 lab=VDD}
N 1712 43565 1732 43565 {lab=VDD}
C {./lab_pin.sym} 1732 43565 0 1 {name=l2320_5 lab=VDD}
N 1712 43585 1732 43585 {lab=VSS}
C {./lab_pin.sym} 1732 43585 0 1 {name=l2320_6 lab=VSS}
N 1712 43605 1732 43605 {lab=VSS}
C {./lab_pin.sym} 1732 43605 0 1 {name=l2320_7 lab=VSS}
C {./dffnrnq_1.sym} 2025 43575 0 0 {name=Xn_2262}
N 1933 43545 1913 43545 {lab=out_cas_int_b22}
C {./lab_pin.sym} 1913 43545 0 0 {name=l2321_0 lab=out_cas_int_b22}
N 1933 43565 1913 43565 {lab=net18}
C {./lab_pin.sym} 1913 43565 0 0 {name=l2321_1 lab=net18}
N 1933 43585 1913 43585 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 1913 43585 0 0 {name=l2321_2 lab=u_clock_div_counter_b7}
N 1933 43605 1913 43605 {lab=u_cas_diff_u_diff1_in_min1_b22}
C {./lab_pin.sym} 1913 43605 0 0 {name=l2321_3 lab=u_cas_diff_u_diff1_in_min1_b22}
N 2117 43545 2137 43545 {lab=VDD}
C {./lab_pin.sym} 2137 43545 0 1 {name=l2321_4 lab=VDD}
N 2117 43565 2137 43565 {lab=VDD}
C {./lab_pin.sym} 2137 43565 0 1 {name=l2321_5 lab=VDD}
N 2117 43585 2137 43585 {lab=VSS}
C {./lab_pin.sym} 2137 43585 0 1 {name=l2321_6 lab=VSS}
N 2117 43605 2137 43605 {lab=VSS}
C {./lab_pin.sym} 2137 43605 0 1 {name=l2321_7 lab=VSS}
C {./dffnrnq_1.sym} 2430 43575 0 0 {name=Xn_2263}
N 2338 43545 2318 43545 {lab=out_cas_int_b23}
C {./lab_pin.sym} 2318 43545 0 0 {name=l2322_0 lab=out_cas_int_b23}
N 2338 43565 2318 43565 {lab=net18}
C {./lab_pin.sym} 2318 43565 0 0 {name=l2322_1 lab=net18}
N 2338 43585 2318 43585 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 2318 43585 0 0 {name=l2322_2 lab=u_clock_div_counter_b7}
N 2338 43605 2318 43605 {lab=u_cas_diff_u_diff1_in_min1_b23}
C {./lab_pin.sym} 2318 43605 0 0 {name=l2322_3 lab=u_cas_diff_u_diff1_in_min1_b23}
N 2522 43545 2542 43545 {lab=VDD}
C {./lab_pin.sym} 2542 43545 0 1 {name=l2322_4 lab=VDD}
N 2522 43565 2542 43565 {lab=VDD}
C {./lab_pin.sym} 2542 43565 0 1 {name=l2322_5 lab=VDD}
N 2522 43585 2542 43585 {lab=VSS}
C {./lab_pin.sym} 2542 43585 0 1 {name=l2322_6 lab=VSS}
N 2522 43605 2542 43605 {lab=VSS}
C {./lab_pin.sym} 2542 43605 0 1 {name=l2322_7 lab=VSS}
C {./dffnrnq_1.sym} 2835 43575 0 0 {name=Xn_2264}
N 2743 43545 2723 43545 {lab=out_cas_int_b24}
C {./lab_pin.sym} 2723 43545 0 0 {name=l2323_0 lab=out_cas_int_b24}
N 2743 43565 2723 43565 {lab=net20}
C {./lab_pin.sym} 2723 43565 0 0 {name=l2323_1 lab=net20}
N 2743 43585 2723 43585 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 2723 43585 0 0 {name=l2323_2 lab=u_clock_div_counter_b7}
N 2743 43605 2723 43605 {lab=u_cas_diff_u_diff1_in_min1_b24}
C {./lab_pin.sym} 2723 43605 0 0 {name=l2323_3 lab=u_cas_diff_u_diff1_in_min1_b24}
N 2927 43545 2947 43545 {lab=VDD}
C {./lab_pin.sym} 2947 43545 0 1 {name=l2323_4 lab=VDD}
N 2927 43565 2947 43565 {lab=VDD}
C {./lab_pin.sym} 2947 43565 0 1 {name=l2323_5 lab=VDD}
N 2927 43585 2947 43585 {lab=VSS}
C {./lab_pin.sym} 2947 43585 0 1 {name=l2323_6 lab=VSS}
N 2927 43605 2947 43605 {lab=VSS}
C {./lab_pin.sym} 2947 43605 0 1 {name=l2323_7 lab=VSS}
C {./dffnrnq_1.sym} 3240 43575 0 0 {name=Xn_2265}
N 3148 43545 3128 43545 {lab=n_0000}
C {./lab_pin.sym} 3128 43545 0 0 {name=l2324_0 lab=n_0000}
N 3148 43565 3128 43565 {lab=net21}
C {./lab_pin.sym} 3128 43565 0 0 {name=l2324_1 lab=net21}
N 3148 43585 3128 43585 {lab=net16}
C {./lab_pin.sym} 3128 43585 0 0 {name=l2324_2 lab=net16}
N 3148 43605 3128 43605 {lab=u_cas_diff_out_diff1_b0}
C {./lab_pin.sym} 3128 43605 0 0 {name=l2324_3 lab=u_cas_diff_out_diff1_b0}
N 3332 43545 3352 43545 {lab=VDD}
C {./lab_pin.sym} 3352 43545 0 1 {name=l2324_4 lab=VDD}
N 3332 43565 3352 43565 {lab=VDD}
C {./lab_pin.sym} 3352 43565 0 1 {name=l2324_5 lab=VDD}
N 3332 43585 3352 43585 {lab=VSS}
C {./lab_pin.sym} 3352 43585 0 1 {name=l2324_6 lab=VSS}
N 3332 43605 3352 43605 {lab=VSS}
C {./lab_pin.sym} 3352 43605 0 1 {name=l2324_7 lab=VSS}
C {./dffnrnq_1.sym} 3645 43575 0 0 {name=Xn_2266}
N 3553 43545 3533 43545 {lab=n_0011}
C {./lab_pin.sym} 3533 43545 0 0 {name=l2325_0 lab=n_0011}
N 3553 43565 3533 43565 {lab=net19}
C {./lab_pin.sym} 3533 43565 0 0 {name=l2325_1 lab=net19}
N 3553 43585 3533 43585 {lab=net16}
C {./lab_pin.sym} 3533 43585 0 0 {name=l2325_2 lab=net16}
N 3553 43605 3533 43605 {lab=u_cas_diff_out_diff1_b1}
C {./lab_pin.sym} 3533 43605 0 0 {name=l2325_3 lab=u_cas_diff_out_diff1_b1}
N 3737 43545 3757 43545 {lab=VDD}
C {./lab_pin.sym} 3757 43545 0 1 {name=l2325_4 lab=VDD}
N 3737 43565 3757 43565 {lab=VDD}
C {./lab_pin.sym} 3757 43565 0 1 {name=l2325_5 lab=VDD}
N 3737 43585 3757 43585 {lab=VSS}
C {./lab_pin.sym} 3757 43585 0 1 {name=l2325_6 lab=VSS}
N 3737 43605 3757 43605 {lab=VSS}
C {./lab_pin.sym} 3757 43605 0 1 {name=l2325_7 lab=VSS}
C {./dffnrnq_1.sym} 4050 43575 0 0 {name=Xn_2267}
N 3958 43545 3938 43545 {lab=n_0017}
C {./lab_pin.sym} 3938 43545 0 0 {name=l2326_0 lab=n_0017}
N 3958 43565 3938 43565 {lab=net19}
C {./lab_pin.sym} 3938 43565 0 0 {name=l2326_1 lab=net19}
N 3958 43585 3938 43585 {lab=net16}
C {./lab_pin.sym} 3938 43585 0 0 {name=l2326_2 lab=net16}
N 3958 43605 3938 43605 {lab=u_cas_diff_out_diff1_b2}
C {./lab_pin.sym} 3938 43605 0 0 {name=l2326_3 lab=u_cas_diff_out_diff1_b2}
N 4142 43545 4162 43545 {lab=VDD}
C {./lab_pin.sym} 4162 43545 0 1 {name=l2326_4 lab=VDD}
N 4142 43565 4162 43565 {lab=VDD}
C {./lab_pin.sym} 4162 43565 0 1 {name=l2326_5 lab=VDD}
N 4142 43585 4162 43585 {lab=VSS}
C {./lab_pin.sym} 4162 43585 0 1 {name=l2326_6 lab=VSS}
N 4142 43605 4162 43605 {lab=VSS}
C {./lab_pin.sym} 4162 43605 0 1 {name=l2326_7 lab=VSS}
C {./dffnrnq_1.sym} 4455 43575 0 0 {name=Xn_2268}
N 4363 43545 4343 43545 {lab=n_0018}
C {./lab_pin.sym} 4343 43545 0 0 {name=l2327_0 lab=n_0018}
N 4363 43565 4343 43565 {lab=net19}
C {./lab_pin.sym} 4343 43565 0 0 {name=l2327_1 lab=net19}
N 4363 43585 4343 43585 {lab=net16}
C {./lab_pin.sym} 4343 43585 0 0 {name=l2327_2 lab=net16}
N 4363 43605 4343 43605 {lab=u_cas_diff_out_diff1_b3}
C {./lab_pin.sym} 4343 43605 0 0 {name=l2327_3 lab=u_cas_diff_out_diff1_b3}
N 4547 43545 4567 43545 {lab=VDD}
C {./lab_pin.sym} 4567 43545 0 1 {name=l2327_4 lab=VDD}
N 4547 43565 4567 43565 {lab=VDD}
C {./lab_pin.sym} 4567 43565 0 1 {name=l2327_5 lab=VDD}
N 4547 43585 4567 43585 {lab=VSS}
C {./lab_pin.sym} 4567 43585 0 1 {name=l2327_6 lab=VSS}
N 4547 43605 4567 43605 {lab=VSS}
C {./lab_pin.sym} 4567 43605 0 1 {name=l2327_7 lab=VSS}
C {./dffnrnq_1.sym} 0 43800 0 0 {name=Xn_2269}
N -92 43770 -112 43770 {lab=n_0019}
C {./lab_pin.sym} -112 43770 0 0 {name=l2328_0 lab=n_0019}
N -92 43790 -112 43790 {lab=net19}
C {./lab_pin.sym} -112 43790 0 0 {name=l2328_1 lab=net19}
N -92 43810 -112 43810 {lab=net16}
C {./lab_pin.sym} -112 43810 0 0 {name=l2328_2 lab=net16}
N -92 43830 -112 43830 {lab=u_cas_diff_out_diff1_b4}
C {./lab_pin.sym} -112 43830 0 0 {name=l2328_3 lab=u_cas_diff_out_diff1_b4}
N 92 43770 112 43770 {lab=VDD}
C {./lab_pin.sym} 112 43770 0 1 {name=l2328_4 lab=VDD}
N 92 43790 112 43790 {lab=VDD}
C {./lab_pin.sym} 112 43790 0 1 {name=l2328_5 lab=VDD}
N 92 43810 112 43810 {lab=VSS}
C {./lab_pin.sym} 112 43810 0 1 {name=l2328_6 lab=VSS}
N 92 43830 112 43830 {lab=VSS}
C {./lab_pin.sym} 112 43830 0 1 {name=l2328_7 lab=VSS}
C {./dffnrnq_1.sym} 405 43800 0 0 {name=Xn_2270}
N 313 43770 293 43770 {lab=n_0020}
C {./lab_pin.sym} 293 43770 0 0 {name=l2329_0 lab=n_0020}
N 313 43790 293 43790 {lab=net19}
C {./lab_pin.sym} 293 43790 0 0 {name=l2329_1 lab=net19}
N 313 43810 293 43810 {lab=net16}
C {./lab_pin.sym} 293 43810 0 0 {name=l2329_2 lab=net16}
N 313 43830 293 43830 {lab=u_cas_diff_out_diff1_b5}
C {./lab_pin.sym} 293 43830 0 0 {name=l2329_3 lab=u_cas_diff_out_diff1_b5}
N 497 43770 517 43770 {lab=VDD}
C {./lab_pin.sym} 517 43770 0 1 {name=l2329_4 lab=VDD}
N 497 43790 517 43790 {lab=VDD}
C {./lab_pin.sym} 517 43790 0 1 {name=l2329_5 lab=VDD}
N 497 43810 517 43810 {lab=VSS}
C {./lab_pin.sym} 517 43810 0 1 {name=l2329_6 lab=VSS}
N 497 43830 517 43830 {lab=VSS}
C {./lab_pin.sym} 517 43830 0 1 {name=l2329_7 lab=VSS}
C {./dffnrnq_1.sym} 810 43800 0 0 {name=Xn_2271}
N 718 43770 698 43770 {lab=n_0021}
C {./lab_pin.sym} 698 43770 0 0 {name=l2330_0 lab=n_0021}
N 718 43790 698 43790 {lab=net19}
C {./lab_pin.sym} 698 43790 0 0 {name=l2330_1 lab=net19}
N 718 43810 698 43810 {lab=net16}
C {./lab_pin.sym} 698 43810 0 0 {name=l2330_2 lab=net16}
N 718 43830 698 43830 {lab=u_cas_diff_out_diff1_b6}
C {./lab_pin.sym} 698 43830 0 0 {name=l2330_3 lab=u_cas_diff_out_diff1_b6}
N 902 43770 922 43770 {lab=VDD}
C {./lab_pin.sym} 922 43770 0 1 {name=l2330_4 lab=VDD}
N 902 43790 922 43790 {lab=VDD}
C {./lab_pin.sym} 922 43790 0 1 {name=l2330_5 lab=VDD}
N 902 43810 922 43810 {lab=VSS}
C {./lab_pin.sym} 922 43810 0 1 {name=l2330_6 lab=VSS}
N 902 43830 922 43830 {lab=VSS}
C {./lab_pin.sym} 922 43830 0 1 {name=l2330_7 lab=VSS}
C {./dffnrnq_1.sym} 1215 43800 0 0 {name=Xn_2272}
N 1123 43770 1103 43770 {lab=n_0022}
C {./lab_pin.sym} 1103 43770 0 0 {name=l2331_0 lab=n_0022}
N 1123 43790 1103 43790 {lab=net19}
C {./lab_pin.sym} 1103 43790 0 0 {name=l2331_1 lab=net19}
N 1123 43810 1103 43810 {lab=net16}
C {./lab_pin.sym} 1103 43810 0 0 {name=l2331_2 lab=net16}
N 1123 43830 1103 43830 {lab=u_cas_diff_out_diff1_b7}
C {./lab_pin.sym} 1103 43830 0 0 {name=l2331_3 lab=u_cas_diff_out_diff1_b7}
N 1307 43770 1327 43770 {lab=VDD}
C {./lab_pin.sym} 1327 43770 0 1 {name=l2331_4 lab=VDD}
N 1307 43790 1327 43790 {lab=VDD}
C {./lab_pin.sym} 1327 43790 0 1 {name=l2331_5 lab=VDD}
N 1307 43810 1327 43810 {lab=VSS}
C {./lab_pin.sym} 1327 43810 0 1 {name=l2331_6 lab=VSS}
N 1307 43830 1327 43830 {lab=VSS}
C {./lab_pin.sym} 1327 43830 0 1 {name=l2331_7 lab=VSS}
C {./dffnrnq_1.sym} 1620 43800 0 0 {name=Xn_2273}
N 1528 43770 1508 43770 {lab=n_0023}
C {./lab_pin.sym} 1508 43770 0 0 {name=l2332_0 lab=n_0023}
N 1528 43790 1508 43790 {lab=net19}
C {./lab_pin.sym} 1508 43790 0 0 {name=l2332_1 lab=net19}
N 1528 43810 1508 43810 {lab=net16}
C {./lab_pin.sym} 1508 43810 0 0 {name=l2332_2 lab=net16}
N 1528 43830 1508 43830 {lab=u_cas_diff_out_diff1_b8}
C {./lab_pin.sym} 1508 43830 0 0 {name=l2332_3 lab=u_cas_diff_out_diff1_b8}
N 1712 43770 1732 43770 {lab=VDD}
C {./lab_pin.sym} 1732 43770 0 1 {name=l2332_4 lab=VDD}
N 1712 43790 1732 43790 {lab=VDD}
C {./lab_pin.sym} 1732 43790 0 1 {name=l2332_5 lab=VDD}
N 1712 43810 1732 43810 {lab=VSS}
C {./lab_pin.sym} 1732 43810 0 1 {name=l2332_6 lab=VSS}
N 1712 43830 1732 43830 {lab=VSS}
C {./lab_pin.sym} 1732 43830 0 1 {name=l2332_7 lab=VSS}
C {./dffnrnq_1.sym} 2025 43800 0 0 {name=Xn_2274}
N 1933 43770 1913 43770 {lab=n_0024}
C {./lab_pin.sym} 1913 43770 0 0 {name=l2333_0 lab=n_0024}
N 1933 43790 1913 43790 {lab=net19}
C {./lab_pin.sym} 1913 43790 0 0 {name=l2333_1 lab=net19}
N 1933 43810 1913 43810 {lab=net16}
C {./lab_pin.sym} 1913 43810 0 0 {name=l2333_2 lab=net16}
N 1933 43830 1913 43830 {lab=u_cas_diff_out_diff1_b9}
C {./lab_pin.sym} 1913 43830 0 0 {name=l2333_3 lab=u_cas_diff_out_diff1_b9}
N 2117 43770 2137 43770 {lab=VDD}
C {./lab_pin.sym} 2137 43770 0 1 {name=l2333_4 lab=VDD}
N 2117 43790 2137 43790 {lab=VDD}
C {./lab_pin.sym} 2137 43790 0 1 {name=l2333_5 lab=VDD}
N 2117 43810 2137 43810 {lab=VSS}
C {./lab_pin.sym} 2137 43810 0 1 {name=l2333_6 lab=VSS}
N 2117 43830 2137 43830 {lab=VSS}
C {./lab_pin.sym} 2137 43830 0 1 {name=l2333_7 lab=VSS}
C {./dffnrnq_1.sym} 2430 43800 0 0 {name=Xn_2275}
N 2338 43770 2318 43770 {lab=n_0001}
C {./lab_pin.sym} 2318 43770 0 0 {name=l2334_0 lab=n_0001}
N 2338 43790 2318 43790 {lab=net19}
C {./lab_pin.sym} 2318 43790 0 0 {name=l2334_1 lab=net19}
N 2338 43810 2318 43810 {lab=net16}
C {./lab_pin.sym} 2318 43810 0 0 {name=l2334_2 lab=net16}
N 2338 43830 2318 43830 {lab=u_cas_diff_out_diff1_b10}
C {./lab_pin.sym} 2318 43830 0 0 {name=l2334_3 lab=u_cas_diff_out_diff1_b10}
N 2522 43770 2542 43770 {lab=VDD}
C {./lab_pin.sym} 2542 43770 0 1 {name=l2334_4 lab=VDD}
N 2522 43790 2542 43790 {lab=VDD}
C {./lab_pin.sym} 2542 43790 0 1 {name=l2334_5 lab=VDD}
N 2522 43810 2542 43810 {lab=VSS}
C {./lab_pin.sym} 2542 43810 0 1 {name=l2334_6 lab=VSS}
N 2522 43830 2542 43830 {lab=VSS}
C {./lab_pin.sym} 2542 43830 0 1 {name=l2334_7 lab=VSS}
C {./dffnrnq_1.sym} 2835 43800 0 0 {name=Xn_2276}
N 2743 43770 2723 43770 {lab=n_0002}
C {./lab_pin.sym} 2723 43770 0 0 {name=l2335_0 lab=n_0002}
N 2743 43790 2723 43790 {lab=net19}
C {./lab_pin.sym} 2723 43790 0 0 {name=l2335_1 lab=net19}
N 2743 43810 2723 43810 {lab=net16}
C {./lab_pin.sym} 2723 43810 0 0 {name=l2335_2 lab=net16}
N 2743 43830 2723 43830 {lab=u_cas_diff_out_diff1_b11}
C {./lab_pin.sym} 2723 43830 0 0 {name=l2335_3 lab=u_cas_diff_out_diff1_b11}
N 2927 43770 2947 43770 {lab=VDD}
C {./lab_pin.sym} 2947 43770 0 1 {name=l2335_4 lab=VDD}
N 2927 43790 2947 43790 {lab=VDD}
C {./lab_pin.sym} 2947 43790 0 1 {name=l2335_5 lab=VDD}
N 2927 43810 2947 43810 {lab=VSS}
C {./lab_pin.sym} 2947 43810 0 1 {name=l2335_6 lab=VSS}
N 2927 43830 2947 43830 {lab=VSS}
C {./lab_pin.sym} 2947 43830 0 1 {name=l2335_7 lab=VSS}
C {./dffnrnq_1.sym} 3240 43800 0 0 {name=Xn_2277}
N 3148 43770 3128 43770 {lab=n_0003}
C {./lab_pin.sym} 3128 43770 0 0 {name=l2336_0 lab=n_0003}
N 3148 43790 3128 43790 {lab=net19}
C {./lab_pin.sym} 3128 43790 0 0 {name=l2336_1 lab=net19}
N 3148 43810 3128 43810 {lab=net16}
C {./lab_pin.sym} 3128 43810 0 0 {name=l2336_2 lab=net16}
N 3148 43830 3128 43830 {lab=u_cas_diff_out_diff1_b12}
C {./lab_pin.sym} 3128 43830 0 0 {name=l2336_3 lab=u_cas_diff_out_diff1_b12}
N 3332 43770 3352 43770 {lab=VDD}
C {./lab_pin.sym} 3352 43770 0 1 {name=l2336_4 lab=VDD}
N 3332 43790 3352 43790 {lab=VDD}
C {./lab_pin.sym} 3352 43790 0 1 {name=l2336_5 lab=VDD}
N 3332 43810 3352 43810 {lab=VSS}
C {./lab_pin.sym} 3352 43810 0 1 {name=l2336_6 lab=VSS}
N 3332 43830 3352 43830 {lab=VSS}
C {./lab_pin.sym} 3352 43830 0 1 {name=l2336_7 lab=VSS}
C {./dffnrnq_1.sym} 3645 43800 0 0 {name=Xn_2278}
N 3553 43770 3533 43770 {lab=n_0004}
C {./lab_pin.sym} 3533 43770 0 0 {name=l2337_0 lab=n_0004}
N 3553 43790 3533 43790 {lab=net19}
C {./lab_pin.sym} 3533 43790 0 0 {name=l2337_1 lab=net19}
N 3553 43810 3533 43810 {lab=net16}
C {./lab_pin.sym} 3533 43810 0 0 {name=l2337_2 lab=net16}
N 3553 43830 3533 43830 {lab=u_cas_diff_out_diff1_b13}
C {./lab_pin.sym} 3533 43830 0 0 {name=l2337_3 lab=u_cas_diff_out_diff1_b13}
N 3737 43770 3757 43770 {lab=VDD}
C {./lab_pin.sym} 3757 43770 0 1 {name=l2337_4 lab=VDD}
N 3737 43790 3757 43790 {lab=VDD}
C {./lab_pin.sym} 3757 43790 0 1 {name=l2337_5 lab=VDD}
N 3737 43810 3757 43810 {lab=VSS}
C {./lab_pin.sym} 3757 43810 0 1 {name=l2337_6 lab=VSS}
N 3737 43830 3757 43830 {lab=VSS}
C {./lab_pin.sym} 3757 43830 0 1 {name=l2337_7 lab=VSS}
C {./dffnrnq_1.sym} 4050 43800 0 0 {name=Xn_2279}
N 3958 43770 3938 43770 {lab=n_0005}
C {./lab_pin.sym} 3938 43770 0 0 {name=l2338_0 lab=n_0005}
N 3958 43790 3938 43790 {lab=net19}
C {./lab_pin.sym} 3938 43790 0 0 {name=l2338_1 lab=net19}
N 3958 43810 3938 43810 {lab=net16}
C {./lab_pin.sym} 3938 43810 0 0 {name=l2338_2 lab=net16}
N 3958 43830 3938 43830 {lab=u_cas_diff_out_diff1_b14}
C {./lab_pin.sym} 3938 43830 0 0 {name=l2338_3 lab=u_cas_diff_out_diff1_b14}
N 4142 43770 4162 43770 {lab=VDD}
C {./lab_pin.sym} 4162 43770 0 1 {name=l2338_4 lab=VDD}
N 4142 43790 4162 43790 {lab=VDD}
C {./lab_pin.sym} 4162 43790 0 1 {name=l2338_5 lab=VDD}
N 4142 43810 4162 43810 {lab=VSS}
C {./lab_pin.sym} 4162 43810 0 1 {name=l2338_6 lab=VSS}
N 4142 43830 4162 43830 {lab=VSS}
C {./lab_pin.sym} 4162 43830 0 1 {name=l2338_7 lab=VSS}
C {./dffnrnq_1.sym} 4455 43800 0 0 {name=Xn_2280}
N 4363 43770 4343 43770 {lab=n_0006}
C {./lab_pin.sym} 4343 43770 0 0 {name=l2339_0 lab=n_0006}
N 4363 43790 4343 43790 {lab=net19}
C {./lab_pin.sym} 4343 43790 0 0 {name=l2339_1 lab=net19}
N 4363 43810 4343 43810 {lab=net16}
C {./lab_pin.sym} 4343 43810 0 0 {name=l2339_2 lab=net16}
N 4363 43830 4343 43830 {lab=u_cas_diff_out_diff1_b15}
C {./lab_pin.sym} 4343 43830 0 0 {name=l2339_3 lab=u_cas_diff_out_diff1_b15}
N 4547 43770 4567 43770 {lab=VDD}
C {./lab_pin.sym} 4567 43770 0 1 {name=l2339_4 lab=VDD}
N 4547 43790 4567 43790 {lab=VDD}
C {./lab_pin.sym} 4567 43790 0 1 {name=l2339_5 lab=VDD}
N 4547 43810 4567 43810 {lab=VSS}
C {./lab_pin.sym} 4567 43810 0 1 {name=l2339_6 lab=VSS}
N 4547 43830 4567 43830 {lab=VSS}
C {./lab_pin.sym} 4567 43830 0 1 {name=l2339_7 lab=VSS}
C {./dffnrnq_1.sym} 0 44025 0 0 {name=Xn_2281}
N -92 43995 -112 43995 {lab=n_0007}
C {./lab_pin.sym} -112 43995 0 0 {name=l2340_0 lab=n_0007}
N -92 44015 -112 44015 {lab=net19}
C {./lab_pin.sym} -112 44015 0 0 {name=l2340_1 lab=net19}
N -92 44035 -112 44035 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} -112 44035 0 0 {name=l2340_2 lab=u_clock_div_counter_b7}
N -92 44055 -112 44055 {lab=u_cas_diff_out_diff1_b16}
C {./lab_pin.sym} -112 44055 0 0 {name=l2340_3 lab=u_cas_diff_out_diff1_b16}
N 92 43995 112 43995 {lab=VDD}
C {./lab_pin.sym} 112 43995 0 1 {name=l2340_4 lab=VDD}
N 92 44015 112 44015 {lab=VDD}
C {./lab_pin.sym} 112 44015 0 1 {name=l2340_5 lab=VDD}
N 92 44035 112 44035 {lab=VSS}
C {./lab_pin.sym} 112 44035 0 1 {name=l2340_6 lab=VSS}
N 92 44055 112 44055 {lab=VSS}
C {./lab_pin.sym} 112 44055 0 1 {name=l2340_7 lab=VSS}
C {./dffnrnq_1.sym} 405 44025 0 0 {name=Xn_2282}
N 313 43995 293 43995 {lab=n_0008}
C {./lab_pin.sym} 293 43995 0 0 {name=l2341_0 lab=n_0008}
N 313 44015 293 44015 {lab=net19}
C {./lab_pin.sym} 293 44015 0 0 {name=l2341_1 lab=net19}
N 313 44035 293 44035 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 293 44035 0 0 {name=l2341_2 lab=u_clock_div_counter_b7}
N 313 44055 293 44055 {lab=u_cas_diff_out_diff1_b17}
C {./lab_pin.sym} 293 44055 0 0 {name=l2341_3 lab=u_cas_diff_out_diff1_b17}
N 497 43995 517 43995 {lab=VDD}
C {./lab_pin.sym} 517 43995 0 1 {name=l2341_4 lab=VDD}
N 497 44015 517 44015 {lab=VDD}
C {./lab_pin.sym} 517 44015 0 1 {name=l2341_5 lab=VDD}
N 497 44035 517 44035 {lab=VSS}
C {./lab_pin.sym} 517 44035 0 1 {name=l2341_6 lab=VSS}
N 497 44055 517 44055 {lab=VSS}
C {./lab_pin.sym} 517 44055 0 1 {name=l2341_7 lab=VSS}
C {./dffnrnq_1.sym} 810 44025 0 0 {name=Xn_2283}
N 718 43995 698 43995 {lab=n_0009}
C {./lab_pin.sym} 698 43995 0 0 {name=l2342_0 lab=n_0009}
N 718 44015 698 44015 {lab=net19}
C {./lab_pin.sym} 698 44015 0 0 {name=l2342_1 lab=net19}
N 718 44035 698 44035 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 698 44035 0 0 {name=l2342_2 lab=u_clock_div_counter_b7}
N 718 44055 698 44055 {lab=u_cas_diff_out_diff1_b18}
C {./lab_pin.sym} 698 44055 0 0 {name=l2342_3 lab=u_cas_diff_out_diff1_b18}
N 902 43995 922 43995 {lab=VDD}
C {./lab_pin.sym} 922 43995 0 1 {name=l2342_4 lab=VDD}
N 902 44015 922 44015 {lab=VDD}
C {./lab_pin.sym} 922 44015 0 1 {name=l2342_5 lab=VDD}
N 902 44035 922 44035 {lab=VSS}
C {./lab_pin.sym} 922 44035 0 1 {name=l2342_6 lab=VSS}
N 902 44055 922 44055 {lab=VSS}
C {./lab_pin.sym} 922 44055 0 1 {name=l2342_7 lab=VSS}
C {./dffnrnq_1.sym} 1215 44025 0 0 {name=Xn_2284}
N 1123 43995 1103 43995 {lab=n_0010}
C {./lab_pin.sym} 1103 43995 0 0 {name=l2343_0 lab=n_0010}
N 1123 44015 1103 44015 {lab=net19}
C {./lab_pin.sym} 1103 44015 0 0 {name=l2343_1 lab=net19}
N 1123 44035 1103 44035 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 1103 44035 0 0 {name=l2343_2 lab=u_clock_div_counter_b7}
N 1123 44055 1103 44055 {lab=u_cas_diff_out_diff1_b19}
C {./lab_pin.sym} 1103 44055 0 0 {name=l2343_3 lab=u_cas_diff_out_diff1_b19}
N 1307 43995 1327 43995 {lab=VDD}
C {./lab_pin.sym} 1327 43995 0 1 {name=l2343_4 lab=VDD}
N 1307 44015 1327 44015 {lab=VDD}
C {./lab_pin.sym} 1327 44015 0 1 {name=l2343_5 lab=VDD}
N 1307 44035 1327 44035 {lab=VSS}
C {./lab_pin.sym} 1327 44035 0 1 {name=l2343_6 lab=VSS}
N 1307 44055 1327 44055 {lab=VSS}
C {./lab_pin.sym} 1327 44055 0 1 {name=l2343_7 lab=VSS}
C {./dffnrnq_1.sym} 1620 44025 0 0 {name=Xn_2285}
N 1528 43995 1508 43995 {lab=n_0012}
C {./lab_pin.sym} 1508 43995 0 0 {name=l2344_0 lab=n_0012}
N 1528 44015 1508 44015 {lab=net19}
C {./lab_pin.sym} 1508 44015 0 0 {name=l2344_1 lab=net19}
N 1528 44035 1508 44035 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 1508 44035 0 0 {name=l2344_2 lab=u_clock_div_counter_b7}
N 1528 44055 1508 44055 {lab=u_cas_diff_out_diff1_b20}
C {./lab_pin.sym} 1508 44055 0 0 {name=l2344_3 lab=u_cas_diff_out_diff1_b20}
N 1712 43995 1732 43995 {lab=VDD}
C {./lab_pin.sym} 1732 43995 0 1 {name=l2344_4 lab=VDD}
N 1712 44015 1732 44015 {lab=VDD}
C {./lab_pin.sym} 1732 44015 0 1 {name=l2344_5 lab=VDD}
N 1712 44035 1732 44035 {lab=VSS}
C {./lab_pin.sym} 1732 44035 0 1 {name=l2344_6 lab=VSS}
N 1712 44055 1732 44055 {lab=VSS}
C {./lab_pin.sym} 1732 44055 0 1 {name=l2344_7 lab=VSS}
C {./dffnrnq_1.sym} 2025 44025 0 0 {name=Xn_2286}
N 1933 43995 1913 43995 {lab=n_0013}
C {./lab_pin.sym} 1913 43995 0 0 {name=l2345_0 lab=n_0013}
N 1933 44015 1913 44015 {lab=net19}
C {./lab_pin.sym} 1913 44015 0 0 {name=l2345_1 lab=net19}
N 1933 44035 1913 44035 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 1913 44035 0 0 {name=l2345_2 lab=u_clock_div_counter_b7}
N 1933 44055 1913 44055 {lab=u_cas_diff_out_diff1_b21}
C {./lab_pin.sym} 1913 44055 0 0 {name=l2345_3 lab=u_cas_diff_out_diff1_b21}
N 2117 43995 2137 43995 {lab=VDD}
C {./lab_pin.sym} 2137 43995 0 1 {name=l2345_4 lab=VDD}
N 2117 44015 2137 44015 {lab=VDD}
C {./lab_pin.sym} 2137 44015 0 1 {name=l2345_5 lab=VDD}
N 2117 44035 2137 44035 {lab=VSS}
C {./lab_pin.sym} 2137 44035 0 1 {name=l2345_6 lab=VSS}
N 2117 44055 2137 44055 {lab=VSS}
C {./lab_pin.sym} 2137 44055 0 1 {name=l2345_7 lab=VSS}
C {./dffnrnq_1.sym} 2430 44025 0 0 {name=Xn_2287}
N 2338 43995 2318 43995 {lab=n_0014}
C {./lab_pin.sym} 2318 43995 0 0 {name=l2346_0 lab=n_0014}
N 2338 44015 2318 44015 {lab=net19}
C {./lab_pin.sym} 2318 44015 0 0 {name=l2346_1 lab=net19}
N 2338 44035 2318 44035 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 2318 44035 0 0 {name=l2346_2 lab=u_clock_div_counter_b7}
N 2338 44055 2318 44055 {lab=u_cas_diff_out_diff1_b22}
C {./lab_pin.sym} 2318 44055 0 0 {name=l2346_3 lab=u_cas_diff_out_diff1_b22}
N 2522 43995 2542 43995 {lab=VDD}
C {./lab_pin.sym} 2542 43995 0 1 {name=l2346_4 lab=VDD}
N 2522 44015 2542 44015 {lab=VDD}
C {./lab_pin.sym} 2542 44015 0 1 {name=l2346_5 lab=VDD}
N 2522 44035 2542 44035 {lab=VSS}
C {./lab_pin.sym} 2542 44035 0 1 {name=l2346_6 lab=VSS}
N 2522 44055 2542 44055 {lab=VSS}
C {./lab_pin.sym} 2542 44055 0 1 {name=l2346_7 lab=VSS}
C {./dffnrnq_1.sym} 2835 44025 0 0 {name=Xn_2288}
N 2743 43995 2723 43995 {lab=n_0015}
C {./lab_pin.sym} 2723 43995 0 0 {name=l2347_0 lab=n_0015}
N 2743 44015 2723 44015 {lab=net20}
C {./lab_pin.sym} 2723 44015 0 0 {name=l2347_1 lab=net20}
N 2743 44035 2723 44035 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 2723 44035 0 0 {name=l2347_2 lab=u_clock_div_counter_b7}
N 2743 44055 2723 44055 {lab=u_cas_diff_out_diff1_b23}
C {./lab_pin.sym} 2723 44055 0 0 {name=l2347_3 lab=u_cas_diff_out_diff1_b23}
N 2927 43995 2947 43995 {lab=VDD}
C {./lab_pin.sym} 2947 43995 0 1 {name=l2347_4 lab=VDD}
N 2927 44015 2947 44015 {lab=VDD}
C {./lab_pin.sym} 2947 44015 0 1 {name=l2347_5 lab=VDD}
N 2927 44035 2947 44035 {lab=VSS}
C {./lab_pin.sym} 2947 44035 0 1 {name=l2347_6 lab=VSS}
N 2927 44055 2947 44055 {lab=VSS}
C {./lab_pin.sym} 2947 44055 0 1 {name=l2347_7 lab=VSS}
C {./dffnrnq_1.sym} 3240 44025 0 0 {name=Xn_2289}
N 3148 43995 3128 43995 {lab=n_0016}
C {./lab_pin.sym} 3128 43995 0 0 {name=l2348_0 lab=n_0016}
N 3148 44015 3128 44015 {lab=net20}
C {./lab_pin.sym} 3128 44015 0 0 {name=l2348_1 lab=net20}
N 3148 44035 3128 44035 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 3128 44035 0 0 {name=l2348_2 lab=u_clock_div_counter_b7}
N 3148 44055 3128 44055 {lab=u_cas_diff_out_diff1_b24}
C {./lab_pin.sym} 3128 44055 0 0 {name=l2348_3 lab=u_cas_diff_out_diff1_b24}
N 3332 43995 3352 43995 {lab=VDD}
C {./lab_pin.sym} 3352 43995 0 1 {name=l2348_4 lab=VDD}
N 3332 44015 3352 44015 {lab=VDD}
C {./lab_pin.sym} 3352 44015 0 1 {name=l2348_5 lab=VDD}
N 3332 44035 3352 44035 {lab=VSS}
C {./lab_pin.sym} 3352 44035 0 1 {name=l2348_6 lab=VSS}
N 3332 44055 3352 44055 {lab=VSS}
C {./lab_pin.sym} 3352 44055 0 1 {name=l2348_7 lab=VSS}
C {./clkbuf_16.sym} 3645 44025 0 0 {name=Xclkbuf_0_clk}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__clkbuf_16 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -40 72 -40 {}
L 4 72 -40 72 40 {}
L 4 72 40 -72 40 {}
L 4 -72 40 -72 -40 {}
T {@name} -72 -60 0 0 0.33 0.33 {}
T {clkbuf_16} -68 29 0 0 0.2 0.2 {}
L 4 -92 -20 -72 -20 {}
T {I} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {Z} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {VDD} -66 15 0 0 0.16 0.16 {}
L 4 92 -20 72 -20 {}
T {VNW} 50.2 -25 0 0 0.16 0.16 {}
L 4 92 0 72 0 {}
T {VPW} 50.2 -5 0 0 0.16 0.16 {}
L 4 92 20 72 20 {}
T {VSS} 50.2 15 0 0 0.16 0.16 {}
B 5 -94 -22 -90 -18 {name=I dir=inout sim_pinnumber=1}
B 5 -94 -2 -90 2 {name=Z dir=inout sim_pinnumber=2}
B 5 -94 18 -90 22 {name=VDD dir=inout sim_pinnumber=3}
B 5 90 -22 94 -18 {name=VNW dir=inout sim_pinnumber=4}
B 5 90 -2 94 2 {name=VPW dir=inout sim_pinnumber=5}
B 5 90 18 94 22 {name=VSS dir=inout sim_pinnumber=6}
]
N 3553 44005 3533 44005 {lab=clk}
C {./lab_pin.sym} 3533 44005 0 0 {name=l2349_0 lab=clk}
N 3553 44025 3533 44025 {lab=clknet_0_clk}
C {./lab_pin.sym} 3533 44025 0 0 {name=l2349_1 lab=clknet_0_clk}
N 3553 44045 3533 44045 {lab=VDD}
C {./lab_pin.sym} 3533 44045 0 0 {name=l2349_2 lab=VDD}
N 3737 44005 3757 44005 {lab=VDD}
C {./lab_pin.sym} 3757 44005 0 1 {name=l2349_3 lab=VDD}
N 3737 44025 3757 44025 {lab=VSS}
C {./lab_pin.sym} 3757 44025 0 1 {name=l2349_4 lab=VSS}
N 3737 44045 3757 44045 {lab=VSS}
C {./lab_pin.sym} 3757 44045 0 1 {name=l2349_5 lab=VSS}
C {./clkbuf_16.sym} 4050 44025 0 0 {name=Xclkbuf_3_0__f_clk}
N 3958 44005 3938 44005 {lab=clknet_0_clk}
C {./lab_pin.sym} 3938 44005 0 0 {name=l2350_0 lab=clknet_0_clk}
N 3958 44025 3938 44025 {lab=clknet_3_0__leaf_clk}
C {./lab_pin.sym} 3938 44025 0 0 {name=l2350_1 lab=clknet_3_0__leaf_clk}
N 3958 44045 3938 44045 {lab=VDD}
C {./lab_pin.sym} 3938 44045 0 0 {name=l2350_2 lab=VDD}
N 4142 44005 4162 44005 {lab=VDD}
C {./lab_pin.sym} 4162 44005 0 1 {name=l2350_3 lab=VDD}
N 4142 44025 4162 44025 {lab=VSS}
C {./lab_pin.sym} 4162 44025 0 1 {name=l2350_4 lab=VSS}
N 4142 44045 4162 44045 {lab=VSS}
C {./lab_pin.sym} 4162 44045 0 1 {name=l2350_5 lab=VSS}
C {./clkbuf_16.sym} 4455 44025 0 0 {name=Xclkbuf_3_1__f_clk}
N 4363 44005 4343 44005 {lab=clknet_0_clk}
C {./lab_pin.sym} 4343 44005 0 0 {name=l2351_0 lab=clknet_0_clk}
N 4363 44025 4343 44025 {lab=clknet_3_1__leaf_clk}
C {./lab_pin.sym} 4343 44025 0 0 {name=l2351_1 lab=clknet_3_1__leaf_clk}
N 4363 44045 4343 44045 {lab=VDD}
C {./lab_pin.sym} 4343 44045 0 0 {name=l2351_2 lab=VDD}
N 4547 44005 4567 44005 {lab=VDD}
C {./lab_pin.sym} 4567 44005 0 1 {name=l2351_3 lab=VDD}
N 4547 44025 4567 44025 {lab=VSS}
C {./lab_pin.sym} 4567 44025 0 1 {name=l2351_4 lab=VSS}
N 4547 44045 4567 44045 {lab=VSS}
C {./lab_pin.sym} 4567 44045 0 1 {name=l2351_5 lab=VSS}
C {./clkbuf_16.sym} 0 44250 0 0 {name=Xclkbuf_3_2__f_clk}
N -92 44230 -112 44230 {lab=clknet_0_clk}
C {./lab_pin.sym} -112 44230 0 0 {name=l2352_0 lab=clknet_0_clk}
N -92 44250 -112 44250 {lab=clknet_3_2__leaf_clk}
C {./lab_pin.sym} -112 44250 0 0 {name=l2352_1 lab=clknet_3_2__leaf_clk}
N -92 44270 -112 44270 {lab=VDD}
C {./lab_pin.sym} -112 44270 0 0 {name=l2352_2 lab=VDD}
N 92 44230 112 44230 {lab=VDD}
C {./lab_pin.sym} 112 44230 0 1 {name=l2352_3 lab=VDD}
N 92 44250 112 44250 {lab=VSS}
C {./lab_pin.sym} 112 44250 0 1 {name=l2352_4 lab=VSS}
N 92 44270 112 44270 {lab=VSS}
C {./lab_pin.sym} 112 44270 0 1 {name=l2352_5 lab=VSS}
C {./clkbuf_16.sym} 405 44250 0 0 {name=Xclkbuf_3_3__f_clk}
N 313 44230 293 44230 {lab=clknet_0_clk}
C {./lab_pin.sym} 293 44230 0 0 {name=l2353_0 lab=clknet_0_clk}
N 313 44250 293 44250 {lab=clknet_3_3__leaf_clk}
C {./lab_pin.sym} 293 44250 0 0 {name=l2353_1 lab=clknet_3_3__leaf_clk}
N 313 44270 293 44270 {lab=VDD}
C {./lab_pin.sym} 293 44270 0 0 {name=l2353_2 lab=VDD}
N 497 44230 517 44230 {lab=VDD}
C {./lab_pin.sym} 517 44230 0 1 {name=l2353_3 lab=VDD}
N 497 44250 517 44250 {lab=VSS}
C {./lab_pin.sym} 517 44250 0 1 {name=l2353_4 lab=VSS}
N 497 44270 517 44270 {lab=VSS}
C {./lab_pin.sym} 517 44270 0 1 {name=l2353_5 lab=VSS}
C {./clkbuf_16.sym} 810 44250 0 0 {name=Xclkbuf_3_4__f_clk}
N 718 44230 698 44230 {lab=clknet_0_clk}
C {./lab_pin.sym} 698 44230 0 0 {name=l2354_0 lab=clknet_0_clk}
N 718 44250 698 44250 {lab=clknet_3_4__leaf_clk}
C {./lab_pin.sym} 698 44250 0 0 {name=l2354_1 lab=clknet_3_4__leaf_clk}
N 718 44270 698 44270 {lab=VDD}
C {./lab_pin.sym} 698 44270 0 0 {name=l2354_2 lab=VDD}
N 902 44230 922 44230 {lab=VDD}
C {./lab_pin.sym} 922 44230 0 1 {name=l2354_3 lab=VDD}
N 902 44250 922 44250 {lab=VSS}
C {./lab_pin.sym} 922 44250 0 1 {name=l2354_4 lab=VSS}
N 902 44270 922 44270 {lab=VSS}
C {./lab_pin.sym} 922 44270 0 1 {name=l2354_5 lab=VSS}
C {./clkbuf_16.sym} 1215 44250 0 0 {name=Xclkbuf_3_5__f_clk}
N 1123 44230 1103 44230 {lab=clknet_0_clk}
C {./lab_pin.sym} 1103 44230 0 0 {name=l2355_0 lab=clknet_0_clk}
N 1123 44250 1103 44250 {lab=clknet_3_5__leaf_clk}
C {./lab_pin.sym} 1103 44250 0 0 {name=l2355_1 lab=clknet_3_5__leaf_clk}
N 1123 44270 1103 44270 {lab=VDD}
C {./lab_pin.sym} 1103 44270 0 0 {name=l2355_2 lab=VDD}
N 1307 44230 1327 44230 {lab=VDD}
C {./lab_pin.sym} 1327 44230 0 1 {name=l2355_3 lab=VDD}
N 1307 44250 1327 44250 {lab=VSS}
C {./lab_pin.sym} 1327 44250 0 1 {name=l2355_4 lab=VSS}
N 1307 44270 1327 44270 {lab=VSS}
C {./lab_pin.sym} 1327 44270 0 1 {name=l2355_5 lab=VSS}
C {./clkbuf_16.sym} 1620 44250 0 0 {name=Xclkbuf_3_6__f_clk}
N 1528 44230 1508 44230 {lab=clknet_0_clk}
C {./lab_pin.sym} 1508 44230 0 0 {name=l2356_0 lab=clknet_0_clk}
N 1528 44250 1508 44250 {lab=clknet_3_6__leaf_clk}
C {./lab_pin.sym} 1508 44250 0 0 {name=l2356_1 lab=clknet_3_6__leaf_clk}
N 1528 44270 1508 44270 {lab=VDD}
C {./lab_pin.sym} 1508 44270 0 0 {name=l2356_2 lab=VDD}
N 1712 44230 1732 44230 {lab=VDD}
C {./lab_pin.sym} 1732 44230 0 1 {name=l2356_3 lab=VDD}
N 1712 44250 1732 44250 {lab=VSS}
C {./lab_pin.sym} 1732 44250 0 1 {name=l2356_4 lab=VSS}
N 1712 44270 1732 44270 {lab=VSS}
C {./lab_pin.sym} 1732 44270 0 1 {name=l2356_5 lab=VSS}
C {./clkbuf_16.sym} 2025 44250 0 0 {name=Xclkbuf_3_7__f_clk}
N 1933 44230 1913 44230 {lab=clknet_0_clk}
C {./lab_pin.sym} 1913 44230 0 0 {name=l2357_0 lab=clknet_0_clk}
N 1933 44250 1913 44250 {lab=clknet_3_7__leaf_clk}
C {./lab_pin.sym} 1913 44250 0 0 {name=l2357_1 lab=clknet_3_7__leaf_clk}
N 1933 44270 1913 44270 {lab=VDD}
C {./lab_pin.sym} 1913 44270 0 0 {name=l2357_2 lab=VDD}
N 2117 44230 2137 44230 {lab=VDD}
C {./lab_pin.sym} 2137 44230 0 1 {name=l2357_3 lab=VDD}
N 2117 44250 2137 44250 {lab=VSS}
C {./lab_pin.sym} 2137 44250 0 1 {name=l2357_4 lab=VSS}
N 2117 44270 2137 44270 {lab=VSS}
C {./lab_pin.sym} 2137 44270 0 1 {name=l2357_5 lab=VSS}
C {./inv_4.sym} 2430 44250 0 0 {name=Xclkload0}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__inv_4 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -40 72 -40 {}
L 4 72 -40 72 40 {}
L 4 72 40 -72 40 {}
L 4 -72 40 -72 -40 {}
T {@name} -72 -60 0 0 0.33 0.33 {}
T {inv_4} -68 29 0 0 0.2 0.2 {}
L 4 -92 -20 -72 -20 {}
T {I} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {ZN} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {VDD} -66 15 0 0 0.16 0.16 {}
L 4 92 -20 72 -20 {}
T {VNW} 50.2 -25 0 0 0.16 0.16 {}
L 4 92 0 72 0 {}
T {VPW} 50.2 -5 0 0 0.16 0.16 {}
L 4 92 20 72 20 {}
T {VSS} 50.2 15 0 0 0.16 0.16 {}
B 5 -94 -22 -90 -18 {name=I dir=inout sim_pinnumber=1}
B 5 -94 -2 -90 2 {name=ZN dir=inout sim_pinnumber=2}
B 5 -94 18 -90 22 {name=VDD dir=inout sim_pinnumber=3}
B 5 90 -22 94 -18 {name=VNW dir=inout sim_pinnumber=4}
B 5 90 -2 94 2 {name=VPW dir=inout sim_pinnumber=5}
B 5 90 18 94 22 {name=VSS dir=inout sim_pinnumber=6}
]
N 2338 44230 2318 44230 {lab=clknet_3_1__leaf_clk}
C {./lab_pin.sym} 2318 44230 0 0 {name=l2358_0 lab=clknet_3_1__leaf_clk}
N 2338 44250 2318 44250 {lab=NC_clkload0_ZN}
C {./lab_pin.sym} 2318 44250 0 0 {name=l2358_1 lab=NC_clkload0_ZN}
N 2338 44270 2318 44270 {lab=VDD}
C {./lab_pin.sym} 2318 44270 0 0 {name=l2358_2 lab=VDD}
N 2522 44230 2542 44230 {lab=VDD}
C {./lab_pin.sym} 2542 44230 0 1 {name=l2358_3 lab=VDD}
N 2522 44250 2542 44250 {lab=VSS}
C {./lab_pin.sym} 2542 44250 0 1 {name=l2358_4 lab=VSS}
N 2522 44270 2542 44270 {lab=VSS}
C {./lab_pin.sym} 2542 44270 0 1 {name=l2358_5 lab=VSS}
C {./clkinv_2.sym} 2835 44250 0 0 {name=Xclkload1}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__clkinv_2 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -40 72 -40 {}
L 4 72 -40 72 40 {}
L 4 72 40 -72 40 {}
L 4 -72 40 -72 -40 {}
T {@name} -72 -60 0 0 0.33 0.33 {}
T {clkinv_2} -68 29 0 0 0.2 0.2 {}
L 4 -92 -20 -72 -20 {}
T {I} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {ZN} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {VDD} -66 15 0 0 0.16 0.16 {}
L 4 92 -20 72 -20 {}
T {VNW} 50.2 -25 0 0 0.16 0.16 {}
L 4 92 0 72 0 {}
T {VPW} 50.2 -5 0 0 0.16 0.16 {}
L 4 92 20 72 20 {}
T {VSS} 50.2 15 0 0 0.16 0.16 {}
B 5 -94 -22 -90 -18 {name=I dir=inout sim_pinnumber=1}
B 5 -94 -2 -90 2 {name=ZN dir=inout sim_pinnumber=2}
B 5 -94 18 -90 22 {name=VDD dir=inout sim_pinnumber=3}
B 5 90 -22 94 -18 {name=VNW dir=inout sim_pinnumber=4}
B 5 90 -2 94 2 {name=VPW dir=inout sim_pinnumber=5}
B 5 90 18 94 22 {name=VSS dir=inout sim_pinnumber=6}
]
N 2743 44230 2723 44230 {lab=clknet_3_2__leaf_clk}
C {./lab_pin.sym} 2723 44230 0 0 {name=l2359_0 lab=clknet_3_2__leaf_clk}
N 2743 44250 2723 44250 {lab=NC_clkload1_ZN}
C {./lab_pin.sym} 2723 44250 0 0 {name=l2359_1 lab=NC_clkload1_ZN}
N 2743 44270 2723 44270 {lab=VDD}
C {./lab_pin.sym} 2723 44270 0 0 {name=l2359_2 lab=VDD}
N 2927 44230 2947 44230 {lab=VDD}
C {./lab_pin.sym} 2947 44230 0 1 {name=l2359_3 lab=VDD}
N 2927 44250 2947 44250 {lab=VSS}
C {./lab_pin.sym} 2947 44250 0 1 {name=l2359_4 lab=VSS}
N 2927 44270 2947 44270 {lab=VSS}
C {./lab_pin.sym} 2947 44270 0 1 {name=l2359_5 lab=VSS}
C {./inv_4.sym} 3240 44250 0 0 {name=Xclkload2}
N 3148 44230 3128 44230 {lab=clknet_3_3__leaf_clk}
C {./lab_pin.sym} 3128 44230 0 0 {name=l2360_0 lab=clknet_3_3__leaf_clk}
N 3148 44250 3128 44250 {lab=NC_clkload2_ZN}
C {./lab_pin.sym} 3128 44250 0 0 {name=l2360_1 lab=NC_clkload2_ZN}
N 3148 44270 3128 44270 {lab=VDD}
C {./lab_pin.sym} 3128 44270 0 0 {name=l2360_2 lab=VDD}
N 3332 44230 3352 44230 {lab=VDD}
C {./lab_pin.sym} 3352 44230 0 1 {name=l2360_3 lab=VDD}
N 3332 44250 3352 44250 {lab=VSS}
C {./lab_pin.sym} 3352 44250 0 1 {name=l2360_4 lab=VSS}
N 3332 44270 3352 44270 {lab=VSS}
C {./lab_pin.sym} 3352 44270 0 1 {name=l2360_5 lab=VSS}
C {./inv_4.sym} 3645 44250 0 0 {name=Xclkload3}
N 3553 44230 3533 44230 {lab=clknet_3_4__leaf_clk}
C {./lab_pin.sym} 3533 44230 0 0 {name=l2361_0 lab=clknet_3_4__leaf_clk}
N 3553 44250 3533 44250 {lab=NC_clkload3_ZN}
C {./lab_pin.sym} 3533 44250 0 0 {name=l2361_1 lab=NC_clkload3_ZN}
N 3553 44270 3533 44270 {lab=VDD}
C {./lab_pin.sym} 3533 44270 0 0 {name=l2361_2 lab=VDD}
N 3737 44230 3757 44230 {lab=VDD}
C {./lab_pin.sym} 3757 44230 0 1 {name=l2361_3 lab=VDD}
N 3737 44250 3757 44250 {lab=VSS}
C {./lab_pin.sym} 3757 44250 0 1 {name=l2361_4 lab=VSS}
N 3737 44270 3757 44270 {lab=VSS}
C {./lab_pin.sym} 3757 44270 0 1 {name=l2361_5 lab=VSS}
C {./inv_2.sym} 4050 44250 0 0 {name=Xclkload4}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__inv_2 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -40 72 -40 {}
L 4 72 -40 72 40 {}
L 4 72 40 -72 40 {}
L 4 -72 40 -72 -40 {}
T {@name} -72 -60 0 0 0.33 0.33 {}
T {inv_2} -68 29 0 0 0.2 0.2 {}
L 4 -92 -20 -72 -20 {}
T {I} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {ZN} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {VDD} -66 15 0 0 0.16 0.16 {}
L 4 92 -20 72 -20 {}
T {VNW} 50.2 -25 0 0 0.16 0.16 {}
L 4 92 0 72 0 {}
T {VPW} 50.2 -5 0 0 0.16 0.16 {}
L 4 92 20 72 20 {}
T {VSS} 50.2 15 0 0 0.16 0.16 {}
B 5 -94 -22 -90 -18 {name=I dir=inout sim_pinnumber=1}
B 5 -94 -2 -90 2 {name=ZN dir=inout sim_pinnumber=2}
B 5 -94 18 -90 22 {name=VDD dir=inout sim_pinnumber=3}
B 5 90 -22 94 -18 {name=VNW dir=inout sim_pinnumber=4}
B 5 90 -2 94 2 {name=VPW dir=inout sim_pinnumber=5}
B 5 90 18 94 22 {name=VSS dir=inout sim_pinnumber=6}
]
N 3958 44230 3938 44230 {lab=clknet_3_5__leaf_clk}
C {./lab_pin.sym} 3938 44230 0 0 {name=l2362_0 lab=clknet_3_5__leaf_clk}
N 3958 44250 3938 44250 {lab=NC_clkload4_ZN}
C {./lab_pin.sym} 3938 44250 0 0 {name=l2362_1 lab=NC_clkload4_ZN}
N 3958 44270 3938 44270 {lab=VDD}
C {./lab_pin.sym} 3938 44270 0 0 {name=l2362_2 lab=VDD}
N 4142 44230 4162 44230 {lab=VDD}
C {./lab_pin.sym} 4162 44230 0 1 {name=l2362_3 lab=VDD}
N 4142 44250 4162 44250 {lab=VSS}
C {./lab_pin.sym} 4162 44250 0 1 {name=l2362_4 lab=VSS}
N 4142 44270 4162 44270 {lab=VSS}
C {./lab_pin.sym} 4162 44270 0 1 {name=l2362_5 lab=VSS}
C {./clkinv_8.sym} 4455 44250 0 0 {name=Xclkload5}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__clkinv_8 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -40 72 -40 {}
L 4 72 -40 72 40 {}
L 4 72 40 -72 40 {}
L 4 -72 40 -72 -40 {}
T {@name} -72 -60 0 0 0.33 0.33 {}
T {clkinv_8} -68 29 0 0 0.2 0.2 {}
L 4 -92 -20 -72 -20 {}
T {I} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {ZN} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {VDD} -66 15 0 0 0.16 0.16 {}
L 4 92 -20 72 -20 {}
T {VNW} 50.2 -25 0 0 0.16 0.16 {}
L 4 92 0 72 0 {}
T {VPW} 50.2 -5 0 0 0.16 0.16 {}
L 4 92 20 72 20 {}
T {VSS} 50.2 15 0 0 0.16 0.16 {}
B 5 -94 -22 -90 -18 {name=I dir=inout sim_pinnumber=1}
B 5 -94 -2 -90 2 {name=ZN dir=inout sim_pinnumber=2}
B 5 -94 18 -90 22 {name=VDD dir=inout sim_pinnumber=3}
B 5 90 -22 94 -18 {name=VNW dir=inout sim_pinnumber=4}
B 5 90 -2 94 2 {name=VPW dir=inout sim_pinnumber=5}
B 5 90 18 94 22 {name=VSS dir=inout sim_pinnumber=6}
]
N 4363 44230 4343 44230 {lab=clknet_3_6__leaf_clk}
C {./lab_pin.sym} 4343 44230 0 0 {name=l2363_0 lab=clknet_3_6__leaf_clk}
N 4363 44250 4343 44250 {lab=NC_clkload5_ZN}
C {./lab_pin.sym} 4343 44250 0 0 {name=l2363_1 lab=NC_clkload5_ZN}
N 4363 44270 4343 44270 {lab=VDD}
C {./lab_pin.sym} 4343 44270 0 0 {name=l2363_2 lab=VDD}
N 4547 44230 4567 44230 {lab=VDD}
C {./lab_pin.sym} 4567 44230 0 1 {name=l2363_3 lab=VDD}
N 4547 44250 4567 44250 {lab=VSS}
C {./lab_pin.sym} 4567 44250 0 1 {name=l2363_4 lab=VSS}
N 4547 44270 4567 44270 {lab=VSS}
C {./lab_pin.sym} 4567 44270 0 1 {name=l2363_5 lab=VSS}
C {./inv_4.sym} 0 44475 0 0 {name=Xclkload6}
N -92 44455 -112 44455 {lab=clknet_3_7__leaf_clk}
C {./lab_pin.sym} -112 44455 0 0 {name=l2364_0 lab=clknet_3_7__leaf_clk}
N -92 44475 -112 44475 {lab=NC_clkload6_ZN}
C {./lab_pin.sym} -112 44475 0 0 {name=l2364_1 lab=NC_clkload6_ZN}
N -92 44495 -112 44495 {lab=VDD}
C {./lab_pin.sym} -112 44495 0 0 {name=l2364_2 lab=VDD}
N 92 44455 112 44455 {lab=VDD}
C {./lab_pin.sym} 112 44455 0 1 {name=l2364_3 lab=VDD}
N 92 44475 112 44475 {lab=VSS}
C {./lab_pin.sym} 112 44475 0 1 {name=l2364_4 lab=VSS}
N 92 44495 112 44495 {lab=VSS}
C {./lab_pin.sym} 112 44495 0 1 {name=l2364_5 lab=VSS}
C {./dlyb_1.sym} 405 44475 0 0 {name=Xinput1}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__dlyb_1 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -40 72 -40 {}
L 4 72 -40 72 40 {}
L 4 72 40 -72 40 {}
L 4 -72 40 -72 -40 {}
T {@name} -72 -60 0 0 0.33 0.33 {}
T {dlyb_1} -68 29 0 0 0.2 0.2 {}
L 4 -92 -20 -72 -20 {}
T {I} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {Z} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {VDD} -66 15 0 0 0.16 0.16 {}
L 4 92 -20 72 -20 {}
T {VNW} 50.2 -25 0 0 0.16 0.16 {}
L 4 92 0 72 0 {}
T {VPW} 50.2 -5 0 0 0.16 0.16 {}
L 4 92 20 72 20 {}
T {VSS} 50.2 15 0 0 0.16 0.16 {}
B 5 -94 -22 -90 -18 {name=I dir=inout sim_pinnumber=1}
B 5 -94 -2 -90 2 {name=Z dir=inout sim_pinnumber=2}
B 5 -94 18 -90 22 {name=VDD dir=inout sim_pinnumber=3}
B 5 90 -22 94 -18 {name=VNW dir=inout sim_pinnumber=4}
B 5 90 -2 94 2 {name=VPW dir=inout sim_pinnumber=5}
B 5 90 18 94 22 {name=VSS dir=inout sim_pinnumber=6}
]
N 313 44455 293 44455 {lab=in_cic}
C {./lab_pin.sym} 293 44455 0 0 {name=l2365_0 lab=in_cic}
N 313 44475 293 44475 {lab=net1}
C {./lab_pin.sym} 293 44475 0 0 {name=l2365_1 lab=net1}
N 313 44495 293 44495 {lab=VDD}
C {./lab_pin.sym} 293 44495 0 0 {name=l2365_2 lab=VDD}
N 497 44455 517 44455 {lab=VDD}
C {./lab_pin.sym} 517 44455 0 1 {name=l2365_3 lab=VDD}
N 497 44475 517 44475 {lab=VSS}
C {./lab_pin.sym} 517 44475 0 1 {name=l2365_4 lab=VSS}
N 497 44495 517 44495 {lab=VSS}
C {./lab_pin.sym} 517 44495 0 1 {name=l2365_5 lab=VSS}
C {./buf_4.sym} 810 44475 0 0 {name=Xinput2}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__buf_4 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -40 72 -40 {}
L 4 72 -40 72 40 {}
L 4 72 40 -72 40 {}
L 4 -72 40 -72 -40 {}
T {@name} -72 -60 0 0 0.33 0.33 {}
T {buf_4} -68 29 0 0 0.2 0.2 {}
L 4 -92 -20 -72 -20 {}
T {I} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {Z} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {VDD} -66 15 0 0 0.16 0.16 {}
L 4 92 -20 72 -20 {}
T {VNW} 50.2 -25 0 0 0.16 0.16 {}
L 4 92 0 72 0 {}
T {VPW} 50.2 -5 0 0 0.16 0.16 {}
L 4 92 20 72 20 {}
T {VSS} 50.2 15 0 0 0.16 0.16 {}
B 5 -94 -22 -90 -18 {name=I dir=inout sim_pinnumber=1}
B 5 -94 -2 -90 2 {name=Z dir=inout sim_pinnumber=2}
B 5 -94 18 -90 22 {name=VDD dir=inout sim_pinnumber=3}
B 5 90 -22 94 -18 {name=VNW dir=inout sim_pinnumber=4}
B 5 90 -2 94 2 {name=VPW dir=inout sim_pinnumber=5}
B 5 90 18 94 22 {name=VSS dir=inout sim_pinnumber=6}
]
N 718 44455 698 44455 {lab=rst}
C {./lab_pin.sym} 698 44455 0 0 {name=l2366_0 lab=rst}
N 718 44475 698 44475 {lab=net2}
C {./lab_pin.sym} 698 44475 0 0 {name=l2366_1 lab=net2}
N 718 44495 698 44495 {lab=VDD}
C {./lab_pin.sym} 698 44495 0 0 {name=l2366_2 lab=VDD}
N 902 44455 922 44455 {lab=VDD}
C {./lab_pin.sym} 922 44455 0 1 {name=l2366_3 lab=VDD}
N 902 44475 922 44475 {lab=VSS}
C {./lab_pin.sym} 922 44475 0 1 {name=l2366_4 lab=VSS}
N 902 44495 922 44495 {lab=VSS}
C {./lab_pin.sym} 922 44495 0 1 {name=l2366_5 lab=VSS}
C {./buf_8.sym} 1215 44475 0 0 {name=Xload_slew15}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__buf_8 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -40 72 -40 {}
L 4 72 -40 72 40 {}
L 4 72 40 -72 40 {}
L 4 -72 40 -72 -40 {}
T {@name} -72 -60 0 0 0.33 0.33 {}
T {buf_8} -68 29 0 0 0.2 0.2 {}
L 4 -92 -20 -72 -20 {}
T {I} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {Z} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {VDD} -66 15 0 0 0.16 0.16 {}
L 4 92 -20 72 -20 {}
T {VNW} 50.2 -25 0 0 0.16 0.16 {}
L 4 92 0 72 0 {}
T {VPW} 50.2 -5 0 0 0.16 0.16 {}
L 4 92 20 72 20 {}
T {VSS} 50.2 15 0 0 0.16 0.16 {}
B 5 -94 -22 -90 -18 {name=I dir=inout sim_pinnumber=1}
B 5 -94 -2 -90 2 {name=Z dir=inout sim_pinnumber=2}
B 5 -94 18 -90 22 {name=VDD dir=inout sim_pinnumber=3}
B 5 90 -22 94 -18 {name=VNW dir=inout sim_pinnumber=4}
B 5 90 -2 94 2 {name=VPW dir=inout sim_pinnumber=5}
B 5 90 18 94 22 {name=VSS dir=inout sim_pinnumber=6}
]
N 1123 44455 1103 44455 {lab=net16}
C {./lab_pin.sym} 1103 44455 0 0 {name=l2367_0 lab=net16}
N 1123 44475 1103 44475 {lab=net15}
C {./lab_pin.sym} 1103 44475 0 0 {name=l2367_1 lab=net15}
N 1123 44495 1103 44495 {lab=VDD}
C {./lab_pin.sym} 1103 44495 0 0 {name=l2367_2 lab=VDD}
N 1307 44455 1327 44455 {lab=VDD}
C {./lab_pin.sym} 1327 44455 0 1 {name=l2367_3 lab=VDD}
N 1307 44475 1327 44475 {lab=VSS}
C {./lab_pin.sym} 1327 44475 0 1 {name=l2367_4 lab=VSS}
N 1307 44495 1327 44495 {lab=VSS}
C {./lab_pin.sym} 1327 44495 0 1 {name=l2367_5 lab=VSS}
C {./buf_8.sym} 1620 44475 0 0 {name=Xload_slew16}
N 1528 44455 1508 44455 {lab=u_clock_div_counter_b7}
C {./lab_pin.sym} 1508 44455 0 0 {name=l2368_0 lab=u_clock_div_counter_b7}
N 1528 44475 1508 44475 {lab=net16}
C {./lab_pin.sym} 1508 44475 0 0 {name=l2368_1 lab=net16}
N 1528 44495 1508 44495 {lab=VDD}
C {./lab_pin.sym} 1508 44495 0 0 {name=l2368_2 lab=VDD}
N 1712 44455 1732 44455 {lab=VDD}
C {./lab_pin.sym} 1732 44455 0 1 {name=l2368_3 lab=VDD}
N 1712 44475 1732 44475 {lab=VSS}
C {./lab_pin.sym} 1732 44475 0 1 {name=l2368_4 lab=VSS}
N 1712 44495 1732 44495 {lab=VSS}
C {./lab_pin.sym} 1732 44495 0 1 {name=l2368_5 lab=VSS}
C {./buf_12.sym} 2025 44475 0 0 {name=Xload_slew17}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__buf_12 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -40 72 -40 {}
L 4 72 -40 72 40 {}
L 4 72 40 -72 40 {}
L 4 -72 40 -72 -40 {}
T {@name} -72 -60 0 0 0.33 0.33 {}
T {buf_12} -68 29 0 0 0.2 0.2 {}
L 4 -92 -20 -72 -20 {}
T {I} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {Z} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {VDD} -66 15 0 0 0.16 0.16 {}
L 4 92 -20 72 -20 {}
T {VNW} 50.2 -25 0 0 0.16 0.16 {}
L 4 92 0 72 0 {}
T {VPW} 50.2 -5 0 0 0.16 0.16 {}
L 4 92 20 72 20 {}
T {VSS} 50.2 15 0 0 0.16 0.16 {}
B 5 -94 -22 -90 -18 {name=I dir=inout sim_pinnumber=1}
B 5 -94 -2 -90 2 {name=Z dir=inout sim_pinnumber=2}
B 5 -94 18 -90 22 {name=VDD dir=inout sim_pinnumber=3}
B 5 90 -22 94 -18 {name=VNW dir=inout sim_pinnumber=4}
B 5 90 -2 94 2 {name=VPW dir=inout sim_pinnumber=5}
B 5 90 18 94 22 {name=VSS dir=inout sim_pinnumber=6}
]
N 1933 44455 1913 44455 {lab=net21}
C {./lab_pin.sym} 1913 44455 0 0 {name=l2369_0 lab=net21}
N 1933 44475 1913 44475 {lab=net17}
C {./lab_pin.sym} 1913 44475 0 0 {name=l2369_1 lab=net17}
N 1933 44495 1913 44495 {lab=VDD}
C {./lab_pin.sym} 1913 44495 0 0 {name=l2369_2 lab=VDD}
N 2117 44455 2137 44455 {lab=VDD}
C {./lab_pin.sym} 2137 44455 0 1 {name=l2369_3 lab=VDD}
N 2117 44475 2137 44475 {lab=VSS}
C {./lab_pin.sym} 2137 44475 0 1 {name=l2369_4 lab=VSS}
N 2117 44495 2137 44495 {lab=VSS}
C {./lab_pin.sym} 2137 44495 0 1 {name=l2369_5 lab=VSS}
C {./clkbuf_20.sym} 2430 44475 0 0 {name=Xload_slew18}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__clkbuf_20 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -40 72 -40 {}
L 4 72 -40 72 40 {}
L 4 72 40 -72 40 {}
L 4 -72 40 -72 -40 {}
T {@name} -72 -60 0 0 0.33 0.33 {}
T {clkbuf_20} -68 29 0 0 0.2 0.2 {}
L 4 -92 -20 -72 -20 {}
T {I} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {Z} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {VDD} -66 15 0 0 0.16 0.16 {}
L 4 92 -20 72 -20 {}
T {VNW} 50.2 -25 0 0 0.16 0.16 {}
L 4 92 0 72 0 {}
T {VPW} 50.2 -5 0 0 0.16 0.16 {}
L 4 92 20 72 20 {}
T {VSS} 50.2 15 0 0 0.16 0.16 {}
B 5 -94 -22 -90 -18 {name=I dir=inout sim_pinnumber=1}
B 5 -94 -2 -90 2 {name=Z dir=inout sim_pinnumber=2}
B 5 -94 18 -90 22 {name=VDD dir=inout sim_pinnumber=3}
B 5 90 -22 94 -18 {name=VNW dir=inout sim_pinnumber=4}
B 5 90 -2 94 2 {name=VPW dir=inout sim_pinnumber=5}
B 5 90 18 94 22 {name=VSS dir=inout sim_pinnumber=6}
]
N 2338 44455 2318 44455 {lab=net21}
C {./lab_pin.sym} 2318 44455 0 0 {name=l2370_0 lab=net21}
N 2338 44475 2318 44475 {lab=net18}
C {./lab_pin.sym} 2318 44475 0 0 {name=l2370_1 lab=net18}
N 2338 44495 2318 44495 {lab=VDD}
C {./lab_pin.sym} 2318 44495 0 0 {name=l2370_2 lab=VDD}
N 2522 44455 2542 44455 {lab=VDD}
C {./lab_pin.sym} 2542 44455 0 1 {name=l2370_3 lab=VDD}
N 2522 44475 2542 44475 {lab=VSS}
C {./lab_pin.sym} 2542 44475 0 1 {name=l2370_4 lab=VSS}
N 2522 44495 2542 44495 {lab=VSS}
C {./lab_pin.sym} 2542 44495 0 1 {name=l2370_5 lab=VSS}
C {./buf_12.sym} 2835 44475 0 0 {name=Xload_slew19}
N 2743 44455 2723 44455 {lab=net21}
C {./lab_pin.sym} 2723 44455 0 0 {name=l2371_0 lab=net21}
N 2743 44475 2723 44475 {lab=net19}
C {./lab_pin.sym} 2723 44475 0 0 {name=l2371_1 lab=net19}
N 2743 44495 2723 44495 {lab=VDD}
C {./lab_pin.sym} 2723 44495 0 0 {name=l2371_2 lab=VDD}
N 2927 44455 2947 44455 {lab=VDD}
C {./lab_pin.sym} 2947 44455 0 1 {name=l2371_3 lab=VDD}
N 2927 44475 2947 44475 {lab=VSS}
C {./lab_pin.sym} 2947 44475 0 1 {name=l2371_4 lab=VSS}
N 2927 44495 2947 44495 {lab=VSS}
C {./lab_pin.sym} 2947 44495 0 1 {name=l2371_5 lab=VSS}
C {./buf_12.sym} 3240 44475 0 0 {name=Xload_slew20}
N 3148 44455 3128 44455 {lab=net2}
C {./lab_pin.sym} 3128 44455 0 0 {name=l2372_0 lab=net2}
N 3148 44475 3128 44475 {lab=net20}
C {./lab_pin.sym} 3128 44475 0 0 {name=l2372_1 lab=net20}
N 3148 44495 3128 44495 {lab=VDD}
C {./lab_pin.sym} 3128 44495 0 0 {name=l2372_2 lab=VDD}
N 3332 44455 3352 44455 {lab=VDD}
C {./lab_pin.sym} 3352 44455 0 1 {name=l2372_3 lab=VDD}
N 3332 44475 3352 44475 {lab=VSS}
C {./lab_pin.sym} 3352 44475 0 1 {name=l2372_4 lab=VSS}
N 3332 44495 3352 44495 {lab=VSS}
C {./lab_pin.sym} 3352 44495 0 1 {name=l2372_5 lab=VSS}
C {./buf_16.sym} 3645 44475 0 0 {name=Xload_slew21}
[
v {xschem version=3.4.8 file_version=1.2}
G {}
K {type=primitive
format="@name @pinlist gf180mcu_fd_sc_mcu7t5v0__buf_16 @extra"
template="name=X1"}
V {}
S {}
E {}

L 4 -72 -40 72 -40 {}
L 4 72 -40 72 40 {}
L 4 72 40 -72 40 {}
L 4 -72 40 -72 -40 {}
T {@name} -72 -60 0 0 0.33 0.33 {}
T {buf_16} -68 29 0 0 0.2 0.2 {}
L 4 -92 -20 -72 -20 {}
T {I} -66 -25 0 0 0.16 0.16 {}
L 4 -92 0 -72 0 {}
T {Z} -66 -5 0 0 0.16 0.16 {}
L 4 -92 20 -72 20 {}
T {VDD} -66 15 0 0 0.16 0.16 {}
L 4 92 -20 72 -20 {}
T {VNW} 50.2 -25 0 0 0.16 0.16 {}
L 4 92 0 72 0 {}
T {VPW} 50.2 -5 0 0 0.16 0.16 {}
L 4 92 20 72 20 {}
T {VSS} 50.2 15 0 0 0.16 0.16 {}
B 5 -94 -22 -90 -18 {name=I dir=inout sim_pinnumber=1}
B 5 -94 -2 -90 2 {name=Z dir=inout sim_pinnumber=2}
B 5 -94 18 -90 22 {name=VDD dir=inout sim_pinnumber=3}
B 5 90 -22 94 -18 {name=VNW dir=inout sim_pinnumber=4}
B 5 90 -2 94 2 {name=VPW dir=inout sim_pinnumber=5}
B 5 90 18 94 22 {name=VSS dir=inout sim_pinnumber=6}
]
N 3553 44455 3533 44455 {lab=net2}
C {./lab_pin.sym} 3533 44455 0 0 {name=l2373_0 lab=net2}
N 3553 44475 3533 44475 {lab=net21}
C {./lab_pin.sym} 3533 44475 0 0 {name=l2373_1 lab=net21}
N 3553 44495 3533 44495 {lab=VDD}
C {./lab_pin.sym} 3533 44495 0 0 {name=l2373_2 lab=VDD}
N 3737 44455 3757 44455 {lab=VDD}
C {./lab_pin.sym} 3757 44455 0 1 {name=l2373_3 lab=VDD}
N 3737 44475 3757 44475 {lab=VSS}
C {./lab_pin.sym} 3757 44475 0 1 {name=l2373_4 lab=VSS}
N 3737 44495 3757 44495 {lab=VSS}
C {./lab_pin.sym} 3757 44495 0 1 {name=l2373_5 lab=VSS}
C {./dlyb_1.sym} 4050 44475 0 0 {name=Xoutput10}
N 3958 44455 3938 44455 {lab=net10}
C {./lab_pin.sym} 3938 44455 0 0 {name=l2374_0 lab=net10}
N 3958 44475 3938 44475 {lab=out_cic_b5}
C {./lab_pin.sym} 3938 44475 0 0 {name=l2374_1 lab=out_cic_b5}
N 3958 44495 3938 44495 {lab=VDD}
C {./lab_pin.sym} 3938 44495 0 0 {name=l2374_2 lab=VDD}
N 4142 44455 4162 44455 {lab=VDD}
C {./lab_pin.sym} 4162 44455 0 1 {name=l2374_3 lab=VDD}
N 4142 44475 4162 44475 {lab=VSS}
C {./lab_pin.sym} 4162 44475 0 1 {name=l2374_4 lab=VSS}
N 4142 44495 4162 44495 {lab=VSS}
C {./lab_pin.sym} 4162 44495 0 1 {name=l2374_5 lab=VSS}
C {./dlyb_1.sym} 4455 44475 0 0 {name=Xoutput11}
N 4363 44455 4343 44455 {lab=net11}
C {./lab_pin.sym} 4343 44455 0 0 {name=l2375_0 lab=net11}
N 4363 44475 4343 44475 {lab=out_cic_b6}
C {./lab_pin.sym} 4343 44475 0 0 {name=l2375_1 lab=out_cic_b6}
N 4363 44495 4343 44495 {lab=VDD}
C {./lab_pin.sym} 4343 44495 0 0 {name=l2375_2 lab=VDD}
N 4547 44455 4567 44455 {lab=VDD}
C {./lab_pin.sym} 4567 44455 0 1 {name=l2375_3 lab=VDD}
N 4547 44475 4567 44475 {lab=VSS}
C {./lab_pin.sym} 4567 44475 0 1 {name=l2375_4 lab=VSS}
N 4547 44495 4567 44495 {lab=VSS}
C {./lab_pin.sym} 4567 44495 0 1 {name=l2375_5 lab=VSS}
C {./dlyb_1.sym} 0 44700 0 0 {name=Xoutput12}
N -92 44680 -112 44680 {lab=net12}
C {./lab_pin.sym} -112 44680 0 0 {name=l2376_0 lab=net12}
N -92 44700 -112 44700 {lab=out_cic_b7}
C {./lab_pin.sym} -112 44700 0 0 {name=l2376_1 lab=out_cic_b7}
N -92 44720 -112 44720 {lab=VDD}
C {./lab_pin.sym} -112 44720 0 0 {name=l2376_2 lab=VDD}
N 92 44680 112 44680 {lab=VDD}
C {./lab_pin.sym} 112 44680 0 1 {name=l2376_3 lab=VDD}
N 92 44700 112 44700 {lab=VSS}
C {./lab_pin.sym} 112 44700 0 1 {name=l2376_4 lab=VSS}
N 92 44720 112 44720 {lab=VSS}
C {./lab_pin.sym} 112 44720 0 1 {name=l2376_5 lab=VSS}
C {./dlyb_1.sym} 405 44700 0 0 {name=Xoutput13}
N 313 44680 293 44680 {lab=net13}
C {./lab_pin.sym} 293 44680 0 0 {name=l2377_0 lab=net13}
N 313 44700 293 44700 {lab=out_cic_b8}
C {./lab_pin.sym} 293 44700 0 0 {name=l2377_1 lab=out_cic_b8}
N 313 44720 293 44720 {lab=VDD}
C {./lab_pin.sym} 293 44720 0 0 {name=l2377_2 lab=VDD}
N 497 44680 517 44680 {lab=VDD}
C {./lab_pin.sym} 517 44680 0 1 {name=l2377_3 lab=VDD}
N 497 44700 517 44700 {lab=VSS}
C {./lab_pin.sym} 517 44700 0 1 {name=l2377_4 lab=VSS}
N 497 44720 517 44720 {lab=VSS}
C {./lab_pin.sym} 517 44720 0 1 {name=l2377_5 lab=VSS}
C {./dlyb_1.sym} 810 44700 0 0 {name=Xoutput14}
N 718 44680 698 44680 {lab=net14}
C {./lab_pin.sym} 698 44680 0 0 {name=l2378_0 lab=net14}
N 718 44700 698 44700 {lab=out_cic_b9}
C {./lab_pin.sym} 698 44700 0 0 {name=l2378_1 lab=out_cic_b9}
N 718 44720 698 44720 {lab=VDD}
C {./lab_pin.sym} 698 44720 0 0 {name=l2378_2 lab=VDD}
N 902 44680 922 44680 {lab=VDD}
C {./lab_pin.sym} 922 44680 0 1 {name=l2378_3 lab=VDD}
N 902 44700 922 44700 {lab=VSS}
C {./lab_pin.sym} 922 44700 0 1 {name=l2378_4 lab=VSS}
N 902 44720 922 44720 {lab=VSS}
C {./lab_pin.sym} 922 44720 0 1 {name=l2378_5 lab=VSS}
C {./dlyb_1.sym} 1215 44700 0 0 {name=Xoutput3}
N 1123 44680 1103 44680 {lab=net3}
C {./lab_pin.sym} 1103 44680 0 0 {name=l2379_0 lab=net3}
N 1123 44700 1103 44700 {lab=out_cic_b0}
C {./lab_pin.sym} 1103 44700 0 0 {name=l2379_1 lab=out_cic_b0}
N 1123 44720 1103 44720 {lab=VDD}
C {./lab_pin.sym} 1103 44720 0 0 {name=l2379_2 lab=VDD}
N 1307 44680 1327 44680 {lab=VDD}
C {./lab_pin.sym} 1327 44680 0 1 {name=l2379_3 lab=VDD}
N 1307 44700 1327 44700 {lab=VSS}
C {./lab_pin.sym} 1327 44700 0 1 {name=l2379_4 lab=VSS}
N 1307 44720 1327 44720 {lab=VSS}
C {./lab_pin.sym} 1327 44720 0 1 {name=l2379_5 lab=VSS}
C {./dlyb_1.sym} 1620 44700 0 0 {name=Xoutput4}
N 1528 44680 1508 44680 {lab=net4}
C {./lab_pin.sym} 1508 44680 0 0 {name=l2380_0 lab=net4}
N 1528 44700 1508 44700 {lab=out_cic_b10}
C {./lab_pin.sym} 1508 44700 0 0 {name=l2380_1 lab=out_cic_b10}
N 1528 44720 1508 44720 {lab=VDD}
C {./lab_pin.sym} 1508 44720 0 0 {name=l2380_2 lab=VDD}
N 1712 44680 1732 44680 {lab=VDD}
C {./lab_pin.sym} 1732 44680 0 1 {name=l2380_3 lab=VDD}
N 1712 44700 1732 44700 {lab=VSS}
C {./lab_pin.sym} 1732 44700 0 1 {name=l2380_4 lab=VSS}
N 1712 44720 1732 44720 {lab=VSS}
C {./lab_pin.sym} 1732 44720 0 1 {name=l2380_5 lab=VSS}
C {./dlyb_1.sym} 2025 44700 0 0 {name=Xoutput5}
N 1933 44680 1913 44680 {lab=net5}
C {./lab_pin.sym} 1913 44680 0 0 {name=l2381_0 lab=net5}
N 1933 44700 1913 44700 {lab=out_cic_b11}
C {./lab_pin.sym} 1913 44700 0 0 {name=l2381_1 lab=out_cic_b11}
N 1933 44720 1913 44720 {lab=VDD}
C {./lab_pin.sym} 1913 44720 0 0 {name=l2381_2 lab=VDD}
N 2117 44680 2137 44680 {lab=VDD}
C {./lab_pin.sym} 2137 44680 0 1 {name=l2381_3 lab=VDD}
N 2117 44700 2137 44700 {lab=VSS}
C {./lab_pin.sym} 2137 44700 0 1 {name=l2381_4 lab=VSS}
N 2117 44720 2137 44720 {lab=VSS}
C {./lab_pin.sym} 2137 44720 0 1 {name=l2381_5 lab=VSS}
C {./dlyb_1.sym} 2430 44700 0 0 {name=Xoutput6}
N 2338 44680 2318 44680 {lab=net6}
C {./lab_pin.sym} 2318 44680 0 0 {name=l2382_0 lab=net6}
N 2338 44700 2318 44700 {lab=out_cic_b1}
C {./lab_pin.sym} 2318 44700 0 0 {name=l2382_1 lab=out_cic_b1}
N 2338 44720 2318 44720 {lab=VDD}
C {./lab_pin.sym} 2318 44720 0 0 {name=l2382_2 lab=VDD}
N 2522 44680 2542 44680 {lab=VDD}
C {./lab_pin.sym} 2542 44680 0 1 {name=l2382_3 lab=VDD}
N 2522 44700 2542 44700 {lab=VSS}
C {./lab_pin.sym} 2542 44700 0 1 {name=l2382_4 lab=VSS}
N 2522 44720 2542 44720 {lab=VSS}
C {./lab_pin.sym} 2542 44720 0 1 {name=l2382_5 lab=VSS}
C {./dlyb_1.sym} 2835 44700 0 0 {name=Xoutput7}
N 2743 44680 2723 44680 {lab=net7}
C {./lab_pin.sym} 2723 44680 0 0 {name=l2383_0 lab=net7}
N 2743 44700 2723 44700 {lab=out_cic_b2}
C {./lab_pin.sym} 2723 44700 0 0 {name=l2383_1 lab=out_cic_b2}
N 2743 44720 2723 44720 {lab=VDD}
C {./lab_pin.sym} 2723 44720 0 0 {name=l2383_2 lab=VDD}
N 2927 44680 2947 44680 {lab=VDD}
C {./lab_pin.sym} 2947 44680 0 1 {name=l2383_3 lab=VDD}
N 2927 44700 2947 44700 {lab=VSS}
C {./lab_pin.sym} 2947 44700 0 1 {name=l2383_4 lab=VSS}
N 2927 44720 2947 44720 {lab=VSS}
C {./lab_pin.sym} 2947 44720 0 1 {name=l2383_5 lab=VSS}
C {./dlyb_1.sym} 3240 44700 0 0 {name=Xoutput8}
N 3148 44680 3128 44680 {lab=net8}
C {./lab_pin.sym} 3128 44680 0 0 {name=l2384_0 lab=net8}
N 3148 44700 3128 44700 {lab=out_cic_b3}
C {./lab_pin.sym} 3128 44700 0 0 {name=l2384_1 lab=out_cic_b3}
N 3148 44720 3128 44720 {lab=VDD}
C {./lab_pin.sym} 3128 44720 0 0 {name=l2384_2 lab=VDD}
N 3332 44680 3352 44680 {lab=VDD}
C {./lab_pin.sym} 3352 44680 0 1 {name=l2384_3 lab=VDD}
N 3332 44700 3352 44700 {lab=VSS}
C {./lab_pin.sym} 3352 44700 0 1 {name=l2384_4 lab=VSS}
N 3332 44720 3352 44720 {lab=VSS}
C {./lab_pin.sym} 3352 44720 0 1 {name=l2384_5 lab=VSS}
C {./dlyb_1.sym} 3645 44700 0 0 {name=Xoutput9}
N 3553 44680 3533 44680 {lab=net9}
C {./lab_pin.sym} 3533 44680 0 0 {name=l2385_0 lab=net9}
N 3553 44700 3533 44700 {lab=out_cic_b4}
C {./lab_pin.sym} 3533 44700 0 0 {name=l2385_1 lab=out_cic_b4}
N 3553 44720 3533 44720 {lab=VDD}
C {./lab_pin.sym} 3533 44720 0 0 {name=l2385_2 lab=VDD}
N 3737 44680 3757 44680 {lab=VDD}
C {./lab_pin.sym} 3757 44680 0 1 {name=l2385_3 lab=VDD}
N 3737 44700 3757 44700 {lab=VSS}
C {./lab_pin.sym} 3757 44700 0 1 {name=l2385_4 lab=VSS}
N 3737 44720 3757 44720 {lab=VSS}
C {./lab_pin.sym} 3757 44720 0 1 {name=l2385_5 lab=VSS}
